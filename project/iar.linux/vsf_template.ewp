# IAR project vsf_template.ewp, settings and files
configuration vsf_template_aic8800 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __VSF__; __AIC__; __AIC8800__; WEBTERMINAL_CFG_EMBED_XTERMJS=DISABLED; LFS_CONFIG=lfs_util_vsf.h; CFG_AIC8800; CFG_HW_PLATFORM=2; CFG_RF_MODE=3; CFG_PMIC; CFG_PMIC_VER_LITE; CFG_PMIC_ITF_ASDMA; CFG_WIFI_STACK; CFG_RSSI_DATAPKT; CFG_DBG; CFG_IPERF; CFG_ROM_VER=255; CFG_DACL_MIXER_MODE=0; CFG_DACR_MIXER_MODE=2; CFG_AIC1000_MIC_MATRIX=0; CONFIG_RWNX; CONFIG_RWNX_LWIP; CFG_EXT_AIC1000; LWIP_NO_STDINT_H=1; LWIP_SO_RCVBUF=1; MEMP_NUM_TCP_PCB=16; MEMP_NUM_NETCONN=16; VSF_USE_FREETYPE=ENABLED; FT2_BUILD_LIBRARY; VSF_FREETYPE_USE_STDIO=ENABLED
  ICCARM.IExtraOptions: --no_unaligned_access --lock_regs=r9
  ICCARM.CCIncludePath2: ..\..\board\aic8800m; ..\..\application\shell\sys\linux\kernel; ..\..\vsf\source; ..\..\vsf\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include; ..\..\vsf\source\shell\sys\linux\include; ..\..\vsf\source\shell\sys\linux\include\simple_libc; ..\..\vsf\source\shell\sys\linux\include\libusb; ..\..\vsf\source\component\3rd-party\littlefs\port; ..\..\vsf\source\component\3rd-party\littlefs\raw; ..\..\vsf\source\component\3rd-party\mbedtls\port; ..\..\vsf\source\component\3rd-party\mbedtls\raw\include; ..\..\vsf\source\component\3rd-party\freetype\port; ..\..\vsf\source\component\3rd-party\freetype\raw\include; ..\..\vsf\source\hal\driver\AIC\AIC8800\port; ..\..\vsf\source\hal\driver\AIC\AIC8800\port\arch\ll; ..\..\vsf\source\hal\driver\AIC\AIC8800\port\rtos; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\lwip\net_al; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\lwip\lwip-STABLE-2_0_2_RELEASE_VER\ports\rtos\include; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\lwip\lwip-STABLE-2_0_2_RELEASE_VER\src\include; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\lwip\lwip-STABLE-2_0_2_RELEASE_VER\src\include\lwip; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\arch; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\arch\boot; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\arch\cmsis; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\common; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\reg; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\ipc; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\stdio_uart; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\iomux; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\dma; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\ticker; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\flash; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\psram; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\pmic; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\sleep; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\aic1000lite_regs; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\sysctrl; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\asdma_mst; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\trng; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\ce; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\time; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\bt; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\bt\patch\mcu; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\aud_proc; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\gpio; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\plf\aic8800\src\driver\aic1000aud_regs; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\audio\asio; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\audio\common; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\audio\device; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\audio\process\audio_proc; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\audio\process\drc; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\audio\process\eq; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\modules\common\api; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\modules\dbg\api; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\wifi\fhost; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\wifi\fhost\application; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\wifi\wlan; ..\..\vsf\source\hal\driver\AIC\AIC8800\vendor\wifi\macif
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: vsf_template.bin
  ILINK.IlinkOutputFile: vsf_template_aic8800.out
  ILINK.IlinkIcfFile: target\AIC8800\aic8800_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration vsf_template_gd32h7xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: __VSF__; __GigaDevice__; __GD32H759IMT6__; GD32H7XX; FT2_BUILD_LIBRARY; VSF_LINUX_USE_X11=DISABLED; LFS_CONFIG=lfs_util_vsf.h; NONETWORK=1; HAVE_FILEIO=1; UNIX=1; LINUX=1; X11_RGBTXT="/root/share/X11/rgb.txt"; USE_ALLOCA=0
  ICCARM.CCIncludePath2: ..\..\board\gd32h7xx; ..\..\vsf\source\hal\driver\GigaDevice\GD32H7XX\common\vendor\Include; ..\..\application\shell\sys\linux\kernel; ..\..\application\shell\sys\linux\kernel\config\lwip; ..\..\application\shell\sys\linux\applets\x11\port; ..\..\application\shell\sys\linux\applets\x11\nanox\src\include; ..\..\application\shell\sys\linux\applets\x11\nanox\src\nx11\X11-local; ..\..\application\shell\sys\linux\applets\x11\nanox\src\nx11; ..\..\application\shell\sys\linux\applets\x11\fltk; ..\..\application\shell\sys\linux\applets\x11\TinyGL\include; ..\..\vsf\source; ..\..\vsf\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include; ..\..\vsf\source\shell\sys\linux\include; ..\..\vsf\source\shell\sys\linux\include\simple_libc; ..\..\vsf\source\shell\sys\linux\include\libusb; ..\..\vsf\source\component\3rd-party\littlefs\port; ..\..\vsf\source\component\3rd-party\littlefs\raw; ..\..\vsf\source\component\3rd-party\mbedtls\port; ..\..\vsf\source\component\3rd-party\mbedtls\raw\include; ..\..\vsf\source\component\3rd-party\zlib\raw; ..\..\vsf\source\component\3rd-party\lwip\port; ..\..\vsf\source\component\3rd-party\lwip\port\vsf; ..\..\vsf\source\component\3rd-party\lwip\raw\src\include; ..\..\vsf\source\component\3rd-party\freetype\port; ..\..\vsf\source\component\3rd-party\freetype\raw\include
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: vsf_template_gd32h7xx.out
  ILINK.IlinkIcfFile: target\GD32H7XX\gd32h7xx.icf
configuration vsf_template_stm32h7xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H743VI ST STM32H743VI
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: __VSF__; __ST__; __STM32H743VI__; STM32H743xx; LFS_CONFIG=lfs_util_vsf.h
  ICCARM.CCIncludePath2: ..\..\board\stm32h7xx; ..\..\application\shell\sys\linux\kernel; ..\..\vsf\source; ..\..\vsf\source\hal\driver\ST\STM32H7XX\common\vendor\cmsis_device_h7\Include; ..\..\vsf\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include; ..\..\vsf\source\shell\sys\linux\include; ..\..\vsf\source\shell\sys\linux\include\simple_libc; ..\..\vsf\source\shell\sys\linux\include\libusb; ..\..\vsf\source\component\3rd-party\littlefs\port; ..\..\vsf\source\component\3rd-party\littlefs\raw; ..\..\vsf\source\component\3rd-party\mbedtls\port; ..\..\vsf\source\component\3rd-party\mbedtls\raw\include
  ILINK.IlinkOutputFile: vsf_template_stm32h7xx.out
configuration vsf_template_sf32lb5xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32H759xM GD GD32H759xM
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: __VSF__; __SiFli__; __SF32LB520U36__; SOC_BF0_HCPU; BSP_USING_PSRAM1; SF32LB52X; VSF_USE_FREETYPE=ENABLED; FT2_BUILD_LIBRARY; VSF_FREETYPE_USE_STDIO=ENABLED
  ICCARM.CCIncludePath2: ..\..\board\sf32lb5xx; ..\..\application\shell\sys\linux\kernel; ..\..\application\shell\sys\linux\kernel\config\lwip; ..\..\vsf\source; ..\..\vsf\source\hal\driver\SiFli\vendor\drivers\cmsis\Include; ..\..\vsf\source\hal\driver\SiFli\vendor\drivers\cmsis\sf32lb52x; ..\..\vsf\source\hal\driver\SiFli\vendor\drivers\Include; ..\..\vsf\source\hal\driver\SiFli\vendor\customer\boards\include; ..\..\vsf\source\hal\driver\SiFli\vendor\external\CMSIS\Include; ..\..\vsf\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include; ..\..\vsf\source\shell\sys\linux\include; ..\..\vsf\source\shell\sys\linux\include\simple_libc; ..\..\vsf\source\shell\sys\linux\include\libusb; ..\..\vsf\source\component\3rd-party\littlefs\port; ..\..\vsf\source\component\3rd-party\littlefs\raw; ..\..\vsf\source\component\3rd-party\mbedtls\port; ..\..\vsf\source\component\3rd-party\mbedtls\raw\include; ..\..\vsf\source\component\3rd-party\freetype\port; ..\..\vsf\source\component\3rd-party\freetype\raw\include; ..\..\vsf\source\component\3rd-party\zlib\raw; ..\..\vsf\source\component\3rd-party\lwip\port; ..\..\vsf\source\component\3rd-party\lwip\port\vsf; ..\..\vsf\source\component\3rd-party\lwip\raw\src\include; ..\..\vsf\source\component\3rd-party\freetype\port; ..\..\vsf\source\component\3rd-party\freetype\raw\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkOutputFile: vsf_template_sf32lb52x.out
  ILINK.IlinkIcfFile: target\SF32LB52X\sf32lb52x_hcpu.icf
configuration vsf_template_n32h7xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H765xIx7 Nations N32H765xIx7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: __VSF__; __VSF_CPP__; __Nations__; __N32H765IIB7EC__; CORE_CM7; N32H76x; FT2_BUILD_LIBRARY; VSF_LINUX_USE_X11=DISABLED; LFS_CONFIG=lfs_util_vsf.h; NONETWORK=1; HAVE_FILEIO=1; UNIX=1; LINUX=1; X11_RGBTXT="/root/share/X11/rgb.txt"; USE_ALLOCA=0
  ICCARM.CCIncludePath2: ..\..\board\n32h7xx; ..\..\vsf\source\hal\driver\Nations\N32H76X_78X\common\vendor; ..\..\application\shell\sys\linux\kernel; ..\..\application\shell\sys\linux\kernel\config\lwip; ..\..\application\shell\sys\linux\applets\x11\port; ..\..\application\shell\sys\linux\applets\x11\nanox\src\include; ..\..\application\shell\sys\linux\applets\x11\nanox\src\nx11\X11-local; ..\..\application\shell\sys\linux\applets\x11\nanox\src\nx11; ..\..\application\shell\sys\linux\applets\x11\fltk; ..\..\application\shell\sys\linux\applets\x11\TinyGL\include; ..\..\vsf\source; ..\..\vsf\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include; ..\..\vsf\source\shell\sys\linux\include; ..\..\vsf\source\shell\sys\linux\include\simple_libc; ..\..\vsf\source\shell\sys\linux\include\libusb; ..\..\vsf\source\component\3rd-party\littlefs\port; ..\..\vsf\source\component\3rd-party\littlefs\raw; ..\..\vsf\source\component\3rd-party\mbedtls\port; ..\..\vsf\source\component\3rd-party\mbedtls\raw\include; ..\..\vsf\source\component\3rd-party\zlib\raw; ..\..\vsf\source\component\3rd-party\lwip\port; ..\..\vsf\source\component\3rd-party\lwip\port\vsf; ..\..\vsf\source\component\3rd-party\lwip\raw\src\include; ..\..\vsf\source\component\3rd-party\freetype\port; ..\..\vsf\source\component\3rd-party\freetype\raw\include
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: vsf_template_gd32h7xx.out
  ILINK.IlinkIcfFile: target\N32H7XX\n32h7xx.icf
configuration vsf_template_at32f405 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F405KCU7-4_v2 ArteryTek AT32F405KCU7-4
  ICCARM.CCDefines: __VSF__; __VSF_CPP__; __Artery__; __AT32F405KCU7_4__; AT32F405KCU7_4; FT2_BUILD_LIBRARY; VSF_LINUX_USE_X11=DISABLED; LFS_CONFIG=lfs_util_vsf.h; NONETWORK=1; HAVE_FILEIO=1; UNIX=1; LINUX=1; X11_RGBTXT="/root/share/X11/rgb.txt"; USE_ALLOCA=0
  ICCARM.CCIncludePath2: ..\..\board\at32f405; ..\..\vsf\source\hal\driver\Artery\AT32F402_405\common; ..\..\vsf\source\hal\driver\Artery\AT32F402_405\common\vendor\libraries\drivers\inc; ..\..\vsf\source\hal\driver\Artery\AT32F402_405\common\vendor\libraries\cmsis\cm4\device_support; ..\..\application\shell\sys\linux\kernel; ..\..\application\shell\sys\linux\kernel\config\lwip; ..\..\application\shell\sys\linux\applets\x11\port; ..\..\application\shell\sys\linux\applets\x11\nanox\src\include; ..\..\application\shell\sys\linux\applets\x11\nanox\src\nx11\X11-local; ..\..\application\shell\sys\linux\applets\x11\nanox\src\nx11; ..\..\application\shell\sys\linux\applets\x11\fltk; ..\..\application\shell\sys\linux\applets\x11\TinyGL\include; ..\..\vsf\source; ..\..\vsf\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include; ..\..\vsf\source\shell\sys\linux\include; ..\..\vsf\source\shell\sys\linux\include\simple_libc; ..\..\vsf\source\shell\sys\linux\include\libusb; ..\..\vsf\source\component\3rd-party\littlefs\port; ..\..\vsf\source\component\3rd-party\littlefs\raw; ..\..\vsf\source\component\3rd-party\mbedtls\port; ..\..\vsf\source\component\3rd-party\mbedtls\raw\include; ..\..\vsf\source\component\3rd-party\zlib\raw; ..\..\vsf\source\component\3rd-party\lwip\port; ..\..\vsf\source\component\3rd-party\lwip\port\vsf; ..\..\vsf\source\component\3rd-party\lwip\raw\src\include; ..\..\vsf\source\component\3rd-party\freetype\port; ..\..\vsf\source\component\3rd-party\freetype\raw\include
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: vsf_template_at32f405.out
  group application
    ../../application/shell/sys/linux/kernel/: hwtest_main.c user_httpd.c user_mdns.c user_qrcode.c user_ui.c vsf_linux_package_manager.c vsf_main.c vsf_usr_cfg.h
  group application/images
    ../../application/shell/sys/linux/kernel/images/: demo_images.c demo_images.h demo_images_data.h
  group application/x11/nanox
    ../../application/shell/sys/linux/applets/x11/nanox/src/demos/nanox/: nxclock.c nxeyes.c nxkbd.c nxkbd_srvconn.c nxterm.c world.c
  group application/x11/nanox/src/drivers
    ../../application/shell/sys/linux/applets/x11/nanox/src/drivers/: fb.c fb.h fblin1.c fblin16.c fblin2.c fblin24.c fblin32.c fblin4.c fblin8.c fbportrait_down.c fbportrait_left.c fbportrait_right.c genfont.c genmem.c genmem.h hbf.c hbf.h kbd_null.c mou_devmice.c mou_null.c osdep.c rasterops.c scr_fb.c
  group application/x11/nanox/src/engine
    ../../application/shell/sys/linux/applets/x11/nanox/src/engine/: convblit_8888.c convblit_frameb.c convblit_mask.c devarc.c devblit.c devclip.c devclip1.c devclip2.c devdraw.c devfont.c devfont.h devimage.c devimage_stretch.c devkbd.c devlist.c devmouse.c devopen.c devpal1.c devpal2.c devpal4.c devpal8.c devpalgray4.c devpoly.c devrgn.c devrgn2.c devstipple.c devtimer.c font_dbcs.c font_eucjp.c font_fnt.c font_freetype2.c font_hbf.c font_hzk.c font_pcf.c font_t1lib.c image_bmp.c image_gif.c image_jpeg.c image_png.c image_pnm.c image_tiff.c image_xpm.c selfont.c
  group application/x11/nanox/src/fonts/compiled
    ../../application/shell/sys/linux/applets/x11/nanox/src/fonts/compiled/: winFreeSansSerif11x13.c X6x13.c
  group application/x11/nanox/src/nanox
    ../../application/shell/sys/linux/applets/x11/nanox/src/nanox/: client.c clientfb.c nxdraw.c nxproto.c nxproto.h nxtransform.c nxutil.c serv.h srvclip.c srvclip1.c srvclip2.c srvevent.c srvfunc.c srvmain.c srvnet.c srvnonet.c srvutil.c wmaction.c wmclients.c wmevents.c wmutil.c
  group application/x11/nanox/src/nx11
    ../../application/shell/sys/linux/applets/x11/nanox/src/nx11/: AllocColor.c Atom.c Backgnd.c BdrWidth.c Bell.c Border.c ChProperty.c ChSaveSet.c ChWindow.c ClassHint.c ClDisplay.c Clear.c ClearArea.c Colormap.c Colorname.c Context.c Copy.c CrBFData.c CrCursor.c CrGC.c CrPFBData.c CrPixmap.c CrWindow.c DefCursor.c DestWind.c DrArc.c DrLine.c DrLines.c DrPoint.c DrRect.c ErrorHandler.c Extension.c FillPolygon.c FillRct.c Flush.c font_find.c FontCursor.c FontInfo.c fontlist.c Free.c FreeGC.c GetGCVals.c GetGeom.c GetPntMap.c GetWMProps.c Grab.c IM.c Image.c keysymstr.h ListPix.c Locale.c LowerWin.c MapRaised.c MapWindow.c Misc.c MoveWin.c NextEvent.c NXext.c nxlib.h OpenDis.c ParseCmd.c ParseColor.c PmapBgnd.c Quarks.c QueryBest.c QueryColor.c QueryFont.c QueryPointer.c QueryTree.c RaiseWin.c Region.c replace-lX11.sh RepWindow.c Request.c Resource.c Screen.c Selection.c SelInput.c SetAttributes.c SetClip.c SetIFocus.c SetWMProps.c SetWMProto.c Shape.c StName.c StrKeysym.c StrToText.c stub.c Sync.c Text.c Text16.c TextExt.c TextToStr.c Threads.c UndefCurs.c UnloadFont.c UnmapWin.c Visual.c Window.c WindowProperty.c Xinerama.c XKB.c XMisc.c Xrm.c XtoNX.h
  group application/x11/port
    ../../application/shell/sys/linux/applets/x11/port/: config.h nanox_nx11_vsf.c nanox_nx11_vsf.h
  group application/x11/port/nanox
    ../../application/shell/sys/linux/applets/x11/port/nanox/: kbd_ttyscan.c keyctrl.c keynorm.c keynum.c keyshft.c StrKeysym.c
  group application/x11/TinyGL
    ../../application/shell/sys/linux/applets/x11/TinyGL/examples/: gears.c nanox.c
  group application/x11/TinyGL/src
    ../../application/shell/sys/linux/applets/x11/TinyGL/src/: api.c arrays.c clear.c clip.c error.c get.c glx.c image_util.c init.c light.c list.c matrix.c memory.c misc.c msghandling.c msghandling.h nglx.c opinfo.h oscontext.c select.c specbuf.c specbuf.h texture.c vertex.c zbuffer.c zbuffer.h zdither.c zfeatures.h zgl.h zline.c zline.h zmath.c zmath.h ztriangle.c ztriangle.h
  group board/aic8800m
    ../../board/aic8800m/: vsf_board.c vsf_board.h vsf_board_cfg.h
  group board/at32f405
    ../../board/at32f405/: vsf_board.c vsf_board.h vsf_board_cfg.h
  group board/gd32h7xx
    ../../board/gd32h7xx/: vsf_board.c vsf_board.h vsf_board_cfg.h
  group board/n32h7xx
    ../../board/n32h7xx/: vsf_board.c vsf_board.h vsf_board_cfg.h
  group board/sf32lb5xx
    ../../board/sf32lb5xx/: vsf_board.c vsf_board.h vsf_board_cfg.h
  group board/sf32lb5xx/vendor
    ../../vsf/source/hal/driver/SiFli/vendor/drivers/cmsis/sf32lb52x/: bf0_pin_const.c
  group board/sf32lb5xx/vendor/hal
    ../../vsf/source/hal/driver/SiFli/vendor/drivers/hal/: bf0_hal_cortex.c bf0_hal_dma.c bf0_hal_gpio.c bf0_hal_hpaon.c bf0_hal_lcdc.c bf0_hal_mpi.c bf0_hal_mpi_ex.c bf0_hal_mpi_psram.c bf0_hal_pinmux.c bf0_hal_pmu.c bf0_hal_rcc.c flash_table.c sifli_bbm.c
  group board/stm32h7xx
    ../../board/stm32h7xx/: vsf_board.c vsf_board.h vsf_board_cfg.h
  group vsf
    ../../vsf/source/: vsf.c vsf.h vsf_cfg.h
  group vsf/component
    ../../vsf/source/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group vsf/component/3rd-party/btstack/firmware/bcm/bcm20702
    ../../vsf/source/component/3rd-party/btstack/firmware/bcm/bcm20702/: bt_firmware_image.c
  group vsf/component/3rd-party/btstack/port
    ../../vsf/source/component/3rd-party/btstack/port/: btstack_run_loop_vsf.c btstack_run_loop_vsf.h hci_dump_vsf.c hci_transport_h2_vsf.c
  group vsf/component/3rd-party/btstack/raw/chipset/bcm
    ../../vsf/source/component/3rd-party/btstack/raw/chipset/bcm/: btstack_chipset_bcm.c btstack_chipset_bcm.h btstack_chipset_bcm_download_firmware.c btstack_chipset_bcm_download_firmware.h
  group vsf/component/3rd-party/btstack/raw/chipset/csr
    ../../vsf/source/component/3rd-party/btstack/raw/chipset/csr/: btstack_chipset_csr.c
  group vsf/component/3rd-party/btstack/raw/src
    ../../vsf/source/component/3rd-party/btstack/raw/src/: ad_parser.c btstack_linked_list.c btstack_memory.c btstack_memory_pool.c btstack_run_loop.c btstack_util.c hci.c hci_cmd.c l2cap.c l2cap_signaling.c
  group vsf/component/3rd-party/btstack/raw/src/classic
    ../../vsf/source/component/3rd-party/btstack/raw/src/classic/: btstack_link_key_db_memory.c btstack_link_key_db_memory.h hid_device.c rfcomm.c sdp_server.c sdp_util.c spp_server.c
  group vsf/component/3rd-party/coremark/port
    ../../vsf/source/component/3rd-party/coremark/port/: core_portme.c core_portme.h
  group vsf/component/3rd-party/coremark/raw
    ../../vsf/source/component/3rd-party/coremark/raw/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
  group vsf/component/3rd-party/evm/extension/bluetooth
    ../../vsf/source/component/3rd-party/evm/extension/bluetooth/: evm_module_bluetooth.c evm_module_bluetooth.h
  group vsf/component/3rd-party/evm/extension/oo
    ../../vsf/source/component/3rd-party/evm/extension/oo/: evm_oo.c evm_oo.h
  group vsf/component/3rd-party/evm/extension/usbh
    ../../vsf/source/component/3rd-party/evm/extension/usbh/: evm_module_usbh.c evm_module_usbh.h
  group vsf/component/3rd-party/evm/port
    ../../vsf/source/component/3rd-party/evm/port/: evm_port.c
  group vsf/component/3rd-party/evm/port/eluaos
    ../../vsf/source/component/3rd-party/evm/port/eluaos/: luat_fs_vsf.c luat_gpio_vsf.c luat_log_vsf.c luat_malloc_vsf.c luat_msgbus_vsf.c luat_netclient_vsf.c luat_socket_vsf.c luat_timer_vsf.c luat_uart_vsf.c luat_vsf_base.c
  group vsf/component/3rd-party/evm/port/iotjs
    ../../vsf/source/component/3rd-party/evm/port/iotjs/: evm_main.c
  group vsf/component/3rd-party/evm/raw/lib/cortex-m3
    ../../vsf/source/component/3rd-party/evm/raw/lib/arm/cortex-m3/: libecma.a libejs.a libelua.a
  group vsf/component/3rd-party/evm/raw/lib/cortex-m4
    ../../vsf/source/component/3rd-party/evm/raw/lib/arm/cortex-m4/: libecma.a libejs.a libelua.a
  group vsf/component/3rd-party/evm/raw/modules/eluaos/lualib
    ../../vsf/source/component/3rd-party/evm/raw/modules/eluaos/lualib/: bget.c lbaselib.c linit.c rotable.c
  group vsf/component/3rd-party/evm/raw/modules/eluaos/modules
    ../../vsf/source/component/3rd-party/evm/raw/modules/eluaos/modules/: luat_lib_gpio.c luat_lib_http.c luat_lib_log.c luat_lib_rtos.c luat_lib_socket.c luat_lib_timer.c luat_lib_uart.c luat_luat_bin.c luat_main.c luat_malloc_weak.c
  group vsf/component/3rd-party/freetype/extension/vplt
    ../../vsf/source/component/3rd-party/freetype/extension/vplt/: freetype_vplt.c freetype_vplt.h
  group vsf/component/3rd-party/freetype/port
    ../../vsf/source/component/3rd-party/freetype/port/: ft2build.h
  group vsf/component/3rd-party/freetype/port/vsf_config
    ../../vsf/source/component/3rd-party/freetype/port/vsf_config/: ftconfig.h ftheader.h ftmodule.h ftoption.h ftstdlib.h
  group vsf/component/3rd-party/freetype/raw/include/freetype
    ../../vsf/source/component/3rd-party/freetype/raw/include/freetype/: freetype.h ftadvanc.h ftbbox.h ftbdf.h ftbitmap.h ftbzip2.h ftcache.h ftchapters.h ftcid.h ftcolor.h ftdriver.h fterrdef.h fterrors.h ftfntfmt.h ftgasp.h ftglyph.h ftgxval.h ftgzip.h ftimage.h ftincrem.h ftlcdfil.h ftlist.h ftlzw.h ftmac.h ftmm.h ftmodapi.h ftmoderr.h ftotval.h ftoutln.h ftparams.h ftpfr.h ftrender.h ftsizes.h ftsnames.h ftstroke.h ftsynth.h ftsystem.h fttrigon.h fttypes.h ftwinfnt.h t1tables.h ttnameid.h tttables.h tttags.h
  group vsf/component/3rd-party/freetype/raw/include/freetype/internal
    ../../vsf/source/component/3rd-party/freetype/raw/include/freetype/internal/: autohint.h cffotypes.h cfftypes.h ftcalc.h ftdebug.h ftdrv.h ftgloadr.h fthash.h ftmemory.h ftobjs.h ftpsprop.h ftrfork.h ftserv.h ftstream.h fttrace.h ftvalid.h internal.h psaux.h pshints.h sfnt.h t1types.h tttypes.h wofftypes.h
  group vsf/component/3rd-party/freetype/raw/include/freetype/internal/services
    ../../vsf/source/component/3rd-party/freetype/raw/include/freetype/internal/services/: svbdf.h svcfftl.h svcid.h svfntfmt.h svgldict.h svgxval.h svkern.h svmetric.h svmm.h svotval.h svpfr.h svpostnm.h svprop.h svpscmap.h svpsinfo.h svsfnt.h svttcmap.h svtteng.h svttglyf.h svwinfnt.h
  group vsf/component/3rd-party/freetype/raw/src
    ../../vsf/source/component/3rd-party/freetype/raw/src/autofit/: autofit.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/bdf/: bdf.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/cff/: cff.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/bzip2/: ftbzip2.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/cache/: ftcache.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/gzip/: ftgzip.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/lzw/: ftlzw.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/gxvalid/: gxvalid.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/otvalid/: otvalid.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/pcf/: pcf.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/pfr/: pfr.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/psaux/: psaux.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/pshinter/: pshinter.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/psnames/: psnames.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/raster/: raster.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/sfnt/: sfnt.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/smooth/: smooth.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/truetype/: truetype.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/type1/: type1.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/cid/: type1cid.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/type42/: type42.c
    ../../vsf/source/component/3rd-party/freetype/raw/src/winfonts/: winfnt.c
  group vsf/component/3rd-party/freetype/raw/src/base
    ../../vsf/source/component/3rd-party/freetype/raw/src/base/: ftbase.c ftbase.h ftbbox.c ftbdf.c ftbitmap.c ftcid.c ftdebug.c ftfstype.c ftgasp.c ftglyph.c ftgxval.c ftinit.c ftmm.c ftotval.c ftpatent.c ftpfr.c ftstroke.c ftsynth.c ftsystem.c fttype1.c ftwinfnt.c
  group vsf/component/3rd-party/libjpeg-turbo/port
    ../../vsf/source/component/3rd-party/libjpeg-turbo/port/: jconfig.h jconfigint.h
  group vsf/component/3rd-party/libjpeg-turbo/raw
    ../../vsf/source/component/3rd-party/libjpeg-turbo/raw/: cderror.h cdjpeg.c cdjpeg.h jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jchuff.h jcicc.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcphuff.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst-tj.c jdatadst.c jdatasrc-tj.c jdatasrc.c jdcoefct.c jdcoefct.h jdcolor.c jdct.h jddctmgr.c jdhuff.c jdhuff.h jdicc.c jdinput.c jdmainct.c jdmainct.h jdmarker.c jdmaster.c jdmaster.h jdmerge.c jdmerge.h jdphuff.c jdpostct.c jdsample.c jdsample.h jdtrans.c jerror.c jerror.h jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jidctred.c jinclude.h jmemmgr.c jmemnobs.c jmemsys.h jmorecfg.h jpeg_nbits_table.h jpegcomp.h jpegint.h jpeglib.h jquant1.c jquant2.c jsimd.h jsimd_none.c jsimddct.h jutils.c jversion.h rdbmp.c rdcolmap.c rdgif.c rdppm.c rdswitch.c rdtarga.c transupp.c transupp.h wrbmp.c wrgif.c wrppm.c wrtarga.c
  group vsf/component/3rd-party/libpng/port
    ../../vsf/source/component/3rd-party/libpng/port/: pnglibconf.h
  group vsf/component/3rd-party/libpng/raw
    ../../vsf/source/component/3rd-party/libpng/raw/: png.c png.h pngconf.h pngdebug.h pngerror.c pngget.c pnginfo.h pngmem.c pngpread.c pngpriv.h pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngstruct.h pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c
  group vsf/component/3rd-party/littlefs/port
    ../../vsf/source/component/3rd-party/littlefs/port/: lfs_port.c lfs_port.h lfs_util_vsf.h
  group vsf/component/3rd-party/littlefs/raw
    ../../vsf/source/component/3rd-party/littlefs/raw/: lfs.c lfs.h lfs_util.c lfs_util.h
  group vsf/component/3rd-party/lua/extension/lovevsf
    ../../vsf/source/component/3rd-party/lua/extension/lovevsf/: lovevsf.c lovevsf.h
  group vsf/component/3rd-party/lua/extension/lovevsf/modules
    ../../vsf/source/component/3rd-party/lua/extension/lovevsf/modules/: l_filesystem.c l_font.c l_graphics.c l_image.c l_timer.c
  group vsf/component/3rd-party/lua/extension/oo
    ../../vsf/source/component/3rd-party/lua/extension/oo/: lua_oo.c lua_oo.h
  group vsf/component/3rd-party/lua/port
    ../../vsf/source/component/3rd-party/lua/port/: lua_port.c
  group vsf/component/3rd-party/lua/raw
    ../../vsf/source/component/3rd-party/lua/raw/: lapi.c lapi.h lauxlib.c lauxlib.h lbaselib.c lcode.c lcode.h lcorolib.c lctype.c lctype.h ldblib.c ldebug.c ldebug.h ldo.c ldo.h ldump.c lfunc.c lfunc.h lgc.c lgc.h linit.c liolib.c ljumptab.h llex.c llex.h llimits.h lmathlib.c lmem.c lmem.h loadlib.c lobject.c lobject.h lopcodes.c lopcodes.h lopnames.h loslib.c lparser.c lparser.h lprefix.h lstate.c lstate.h lstring.c lstring.h lstrlib.c ltable.c ltable.h ltablib.c ltests.c ltests.h ltm.c ltm.h lua.c lua.h luaconf.h lualib.h lundump.c lundump.h lutf8lib.c lvm.c lvm.h lzio.c lzio.h
  group vsf/component/3rd-party/lvgl/extension/lv_lib_freetype/raw
    ../../vsf/source/component/3rd-party/lvgl/extension/lv_lib_freetype/raw/: lv_freetype.c lv_freetype.h
  group vsf/component/3rd-party/lvgl/port
    ../../vsf/source/component/3rd-party/lvgl/port/: vsf_lvgl_port.c vsf_lvgl_port.h
  group vsf/component/3rd-party/lvgl/raw/src
    ../../vsf/source/component/3rd-party/lvgl/raw/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group vsf/component/3rd-party/lvgl/raw/src/lv_core
    ../../vsf/source/component/3rd-party/lvgl/raw/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_obj_style_dec.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group vsf/component/3rd-party/lvgl/raw/src/lv_draw
    ../../vsf/source/component/3rd-party/lvgl/raw/lvgl/src/lv_draw/: lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_blend.c lv_draw_blend.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group vsf/component/3rd-party/lvgl/raw/src/lv_font
    ../../vsf/source/component/3rd-party/lvgl/raw/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group vsf/component/3rd-party/lvgl/raw/src/lv_hal
    ../../vsf/source/component/3rd-party/lvgl/raw/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group vsf/component/3rd-party/lvgl/raw/src/lv_misc
    ../../vsf/source/component/3rd-party/lvgl/raw/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_debug.c lv_debug.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group vsf/component/3rd-party/lvgl/raw/src/lv_themes
    ../../vsf/source/component/3rd-party/lvgl/raw/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_empty.c lv_theme_empty.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_template.c lv_theme_template.h
  group vsf/component/3rd-party/lvgl/raw/src/lv_widgets
    ../../vsf/source/component/3rd-party/lvgl/raw/lvgl/src/lv_widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_chart.c lv_chart.h lv_checkbox.c lv_checkbox.h lv_cont.c lv_cont.h lv_cpicker.c lv_cpicker.h lv_dropdown.c lv_dropdown.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_keyboard.c lv_keyboard.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_linemeter.c lv_linemeter.h lv_list.c lv_list.h lv_msgbox.c lv_msgbox.h lv_objmask.c lv_objmask.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_spinner.c lv_spinner.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_textarea.c lv_textarea.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group vsf/component/3rd-party/lwip/port
    ../../vsf/source/component/3rd-party/lwip/port/: lwip_netdrv_adapter.c lwip_netdrv_adapter.h lwippools.h
  group vsf/component/3rd-party/lwip/port/vsf/arch
    ../../vsf/source/component/3rd-party/lwip/port/vsf/arch/: cc.h perf.h sys_arch.c sys_arch.h
  group vsf/component/3rd-party/lwip/raw/src/api
    ../../vsf/source/component/3rd-party/lwip/raw/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
  group vsf/component/3rd-party/lwip/raw/src/apps/mdns
    ../../vsf/source/component/3rd-party/lwip/raw/src/apps/mdns/: mdns.c
  group vsf/component/3rd-party/lwip/raw/src/core
    ../../vsf/source/component/3rd-party/lwip/raw/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group vsf/component/3rd-party/lwip/raw/src/core/ipv4
    ../../vsf/source/component/3rd-party/lwip/raw/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group vsf/component/3rd-party/lwip/raw/src/core/ipv6
    ../../vsf/source/component/3rd-party/lwip/raw/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group vsf/component/3rd-party/lwip/raw/src/netif
    ../../vsf/source/component/3rd-party/lwip/raw/src/netif/: ethernet.c
  group vsf/component/3rd-party/mbedtls/extension/tls_session
    ../../vsf/source/component/3rd-party/mbedtls/extension/tls_session/: mbedtls_tls_session.c mbedtls_tls_session.h
  group vsf/component/3rd-party/mbedtls/extension/vplt
    ../../vsf/source/component/3rd-party/mbedtls/extension/vplt/: mbedtls_vplt.c mbedtls_vplt.h
  group vsf/component/3rd-party/mbedtls/port
    ../../vsf/source/component/3rd-party/mbedtls/port/: platform_vsf.c platform_vsf.h
  group vsf/component/3rd-party/mbedtls/raw/library
    ../../vsf/source/component/3rd-party/mbedtls/raw/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c common.h constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group vsf/component/3rd-party/nnom/port
    ../../vsf/source/component/3rd-party/nnom/port/: nnom_port.h
  group vsf/component/3rd-party/nnom/raw/inc
    ../../vsf/source/component/3rd-party/nnom/raw/inc/: nnom.h nnom_activations.h nnom_layers.h nnom_local.h nnom_out_shape.h nnom_run.h nnom_utils.h
  group vsf/component/3rd-party/nnom/raw/src/backends
    ../../vsf/source/component/3rd-party/nnom/raw/src/backends/: nnom_local.c nnom_local_q15.c
  group vsf/component/3rd-party/nnom/raw/src/core
    ../../vsf/source/component/3rd-party/nnom/raw/src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
  group vsf/component/3rd-party/nnom/raw/src/layers
    ../../vsf/source/component/3rd-party/nnom/raw/src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
  group vsf/component/3rd-party/nuconsole/raw
    ../../vsf/source/component/3rd-party/nuconsole/raw/: NuConsole.c NuConsole.h NuConsole_Config.h
  group vsf/component/3rd-party/qrcode/raw/src
    ../../vsf/source/component/3rd-party/qrcode/raw/src/: qrcode.c qrcode.h
  group vsf/component/3rd-party/segger/port
    ../../vsf/source/component/3rd-party/segger/port/: SEGGER_SYSVIEW_VSF.c SEGGER_SYSVIEW_VSF.h
  group vsf/component/3rd-party/segger/port/Config
    ../../vsf/source/component/3rd-party/segger/port/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_VSF.c
  group vsf/component/3rd-party/segger/raw/RTT
    ../../vsf/source/component/3rd-party/segger/raw/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
  group vsf/component/3rd-party/segger/raw/SystemView
    ../../vsf/source/component/3rd-party/segger/raw/SystemView/: SEGGER.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group vsf/component/3rd-party/vsfip/raw
    ../../vsf/source/component/3rd-party/vsfip/raw/: vsfip.c vsfip.h
  group vsf/component/3rd-party/vsfip/raw/netif
    ../../vsf/source/component/3rd-party/vsfip/raw/netif/: vsfip_netdrv_adapter.c vsfip_netdrv_adapter.h vsfip_netif.c vsfip_netif.h
  group vsf/component/3rd-party/vsfip/raw/netif/eth
    ../../vsf/source/component/3rd-party/vsfip/raw/netif/eth/: vsfip_eth.c vsfip_eth.h
  group vsf/component/3rd-party/vsfip/raw/proto/dhcp
    ../../vsf/source/component/3rd-party/vsfip/raw/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcp_common.h vsfip_dhcpc.c vsfip_dhcpc.h vsfip_dhcpd.c vsfip_dhcpd.h
  group vsf/component/3rd-party/vsfip/raw/proto/dns
    ../../vsf/source/component/3rd-party/vsfip/raw/proto/dns/: vsfip_dnsc.c vsfip_dnsc.h
  group vsf/component/3rd-party/vsfvm/extension/vsf/kernel
    ../../vsf/source/component/3rd-party/vsfvm/extension/vsf/kernel/: vsfvm_ext_kernel.c vsfvm_ext_kernel.h
  group vsf/component/3rd-party/vsfvm/extension/vsf/libusb
    ../../vsf/source/component/3rd-party/vsfvm/extension/vsf/libusb/: vsfvm_ext_libusb.c vsfvm_ext_libusb.h
  group vsf/component/3rd-party/vsfvm/raw
    ../../vsf/source/component/3rd-party/vsfvm/raw/: vsf_vm.h vsf_vm_cfg.h
  group vsf/component/3rd-party/vsfvm/raw/common
    ../../vsf/source/component/3rd-party/vsfvm/raw/common/: vsfvm_bytecode.h vsfvm_common.h vsfvm_objdump.c vsfvm_objdump.h
  group vsf/component/3rd-party/vsfvm/raw/compiler
    ../../vsf/source/component/3rd-party/vsfvm/raw/compiler/: vsfvm_compiler.c vsfvm_compiler.h vsfvm_snapshot.c vsfvm_snapshot.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer
    ../../vsf/source/component/3rd-party/vsfvm/raw/compiler/lexer/: vsfvm_lexer.c vsfvm_lexer.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer/dart
    ../../vsf/source/component/3rd-party/vsfvm/raw/compiler/lexer/dart/: vsfvm_lexer_dart.c vsfvm_lexer_dart.h
  group vsf/component/3rd-party/vsfvm/raw/extension
    ../../vsf/source/component/3rd-party/vsfvm/raw/extension/: vsfvm_ext.c
  group vsf/component/3rd-party/vsfvm/raw/extension/std
    ../../vsf/source/component/3rd-party/vsfvm/raw/extension/std/: vsfvm_ext_std.c vsfvm_ext_std.h
  group vsf/component/3rd-party/vsfvm/raw/runtime
    ../../vsf/source/component/3rd-party/vsfvm/raw/runtime/: vsfvm_runtime.c vsfvm_runtime.h
  group vsf/component/3rd-party/zlib/raw
    ../../vsf/source/component/3rd-party/zlib/raw/: adler32.c compress.c crc32.c crc32.h deflate.c deflate.h gzclose.c gzguts.h gzlib.c gzread.c gzwrite.c infback.c inffast.c inffast.h inffixed.h inflate.c inflate.h inftrees.c inftrees.h trees.c trees.h uncompr.c zconf.h zlib.h zutil.c zutil.h
  group vsf/component/av
    ../../vsf/source/component/av/: vsf_av.h vsf_av_cfg.h
  group vsf/component/av/audio
    ../../vsf/source/component/av/audio/: vsf_audio.c vsf_audio.h
  group vsf/component/av/audio/decoder/wav
    ../../vsf/source/component/av/audio/decoder/wav/: vsf_wav.c vsf_wav.h
  group vsf/component/av/audio/driver/aic1000a
    ../../vsf/source/component/av/audio/driver/aic1000a/: vsf_aic1000a.c vsf_aic1000a.h
  group vsf/component/av/audio/driver/dummy
    ../../vsf/source/component/av/audio/driver/dummy/: vsf_audio_dummy.c vsf_audio_dummy.h
  group vsf/component/av/audio/driver/i2s
    ../../vsf/source/component/av/audio/driver/i2s/: vsf_audio_i2s.c vsf_audio_i2s.h
  group vsf/component/av/audio/driver/winsound
    ../../vsf/source/component/av/audio/driver/winsound/: vsf_winsound.c vsf_winsound.h
  group vsf/component/crypto
    ../../vsf/source/component/crypto/: vsf_crypto.h vsf_crypto_cfg.h
  group vsf/component/crypto/hash/crc
    ../../vsf/source/component/crypto/hash/crc/: vsf_crc.c vsf_crc.h
  group vsf/component/debugger
    ../../vsf/source/component/debugger/: vsf_debugger.h vsf_debugger_cfg.h
  group vsf/component/debugger/nulink
    ../../vsf/source/component/debugger/nulink/: NuConsole_stream.c NuConsole_stream.h
  group vsf/component/debugger/segger
    ../../vsf/source/component/debugger/segger/: segger_rtt_stream.c segger_rtt_stream.h
  group vsf/component/fs
    ../../vsf/source/component/fs/: vsf_fs.c vsf_fs.h vsf_fs_cfg.h
  group vsf/component/fs/driver/fatfs
    ../../vsf/source/component/fs/driver/fatfs/: vsf_fatfs.c vsf_fatfs.h
  group vsf/component/fs/driver/littlefs
    ../../vsf/source/component/fs/driver/littlefs/: vsf_littlefs.c vsf_littlefs.h
  group vsf/component/fs/driver/malfs
    ../../vsf/source/component/fs/driver/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/fs/driver/memfs
    ../../vsf/source/component/fs/driver/memfs/: vsf_memfs.c vsf_memfs.h
  group vsf/component/fs/driver/romfs
    ../../vsf/source/component/fs/driver/romfs/: vsf_romfs.c vsf_romfs.h
  group vsf/component/fs/driver/winfs
    ../../vsf/source/component/fs/driver/winfs/: vsf_winfs.c vsf_winfs.h
  group vsf/component/input
    ../../vsf/source/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h
  group vsf/component/input/driver/hid
    ../../vsf/source/component/input/driver/hid/: vsf_input_hid.c vsf_input_hid.h
  group vsf/component/input/driver/nspro
    ../../vsf/source/component/input/driver/nspro/: vsf_input_nspro.c vsf_input_nspro.h
  group vsf/component/input/protocol
    ../../vsf/source/component/input/protocol/: vsf_input_gamepad.c vsf_input_gamepad.h vsf_input_keyboard.c vsf_input_keyboard.h vsf_input_mouse.c vsf_input_mouse.h vsf_input_sensor.c vsf_input_sensor.h vsf_input_touchscreen.c vsf_input_touchscreen.h
  group vsf/component/mal
    ../../vsf/source/component/mal/: vsf_mal.c vsf_mal.h vsf_mal_cfg.h
  group vsf/component/mal/driver/cached_mal
    ../../vsf/source/component/mal/driver/cached_mal/: vsf_cached_mal.c vsf_cached_mal.h
  group vsf/component/mal/driver/fakefat32_mal
    ../../vsf/source/component/mal/driver/fakefat32_mal/: vsf_fakefat32_mal.c vsf_fakefat32_mal.h
  group vsf/component/mal/driver/file_mal
    ../../vsf/source/component/mal/driver/file_mal/: vsf_file_mal.c vsf_file_mal.h
  group vsf/component/mal/driver/flash_mal
    ../../vsf/source/component/mal/driver/flash_mal/: vsf_flash_mal.c vsf_flash_mal.h
  group vsf/component/mal/driver/mem_mal
    ../../vsf/source/component/mal/driver/mem_mal/: vsf_mem_mal.c vsf_mem_mal.h
  group vsf/component/mal/driver/mim_mal
    ../../vsf/source/component/mal/driver/mim_mal/: vsf_mim_mal.c vsf_mim_mal.h
  group vsf/component/mal/driver/scsi_mal
    ../../vsf/source/component/mal/driver/scsi_mal/: vsf_scsi_mal.c vsf_scsi_mal.h
  group vsf/component/mal/driver/sdmmc_mal
    ../../vsf/source/component/mal/driver/sdmmc_mal/: vsf_sdmmc_mal.c vsf_sdmmc_mal.h
  group vsf/component/misc
    ../../vsf/source/component/misc/: vsf_component_misc.h
  group vsf/component/misc/led_scan
    ../../vsf/source/component/misc/led_scan/: vsf_led_scan.c vsf_led_scan.h
  group vsf/component/scsi
    ../../vsf/source/component/scsi/: vsf_scsi.c vsf_scsi.h vsf_scsi_cfg.h
  group vsf/component/scsi/driver/mal_scsi
    ../../vsf/source/component/scsi/driver/mal_scsi/: vsf_mal_scsi.c vsf_mal_scsi.h
  group vsf/component/scsi/driver/virtual_scsi
    ../../vsf/source/component/scsi/driver/virtual_scsi/: vsf_virtual_scsi.c vsf_virtual_scsi.h
  group vsf/component/tcpip
    ../../vsf/source/component/tcpip/: vsf_tcpip.h vsf_tcpip_cfg.h
  group vsf/component/tcpip/netdrv
    ../../vsf/source/component/tcpip/netdrv/: vsf_netdrv.c vsf_netdrv.h
  group vsf/component/tcpip/protocol/http/client
    ../../vsf/source/component/tcpip/protocol/http/client/: vsf_http_client.c vsf_http_client.h
  group vsf/component/ui
    ../../vsf/source/component/ui/: vsf_ui.h vsf_ui_cfg.h
  group vsf/component/ui/disp
    ../../vsf/source/component/ui/disp/: vsf_disp.c vsf_disp.h
  group vsf/component/ui/disp/driver/fb
    ../../vsf/source/component/ui/disp/driver/fb/: vsf_disp_fb.c vsf_disp_fb.h
  group vsf/component/ui/disp/driver/mipi_lcd
    ../../vsf/source/component/ui/disp/driver/mipi_lcd/: vsf_disp_mipi_lcd_dcs.h vsf_disp_mipi_spi_lcd.c vsf_disp_mipi_spi_lcd.h
  group vsf/component/ui/disp/driver/usbd_uvc
    ../../vsf/source/component/ui/disp/driver/usbd_uvc/: vsf_disp_usbd_uvc.c vsf_disp_usbd_uvc.h
  group vsf/component/ui/tgui
    ../../vsf/source/component/ui/tgui/: vsf_tgui.c vsf_tgui.h vsf_tgui_cfg.h vsf_tgui_common.c vsf_tgui_common.h vsf_tgui_input.c
  group vsf/component/ui/tgui/controls
    ../../vsf/source/component/ui/tgui/controls/: __vk_tgui_slider.c __vk_tgui_slider.h vsf_msg_tree_cfg.h vsf_tgui_button.c vsf_tgui_button.h vsf_tgui_control.c vsf_tgui_control.h vsf_tgui_controls.h vsf_tgui_controls_common.c vsf_tgui_label.c vsf_tgui_label.h vsf_tgui_list.c vsf_tgui_list.h vsf_tgui_panel.c vsf_tgui_panel.h vsf_tgui_text_list.c vsf_tgui_text_list.h
  group vsf/component/ui/tgui/ext/dynamic
    ../../vsf/source/component/ui/tgui/ext/dynamic/: vsf_tgui_dynamic.c vsf_tgui_dynamic.h
  group vsf/component/ui/tgui/port
    ../../vsf/source/component/ui/tgui/port/: vsf_tgui_port.c vsf_tgui_port.h
  group vsf/component/ui/tgui/port/font
    ../../vsf/source/component/ui/tgui/port/font/: vsf_tgui_font_port_freetype.c vsf_tgui_font_port_lvgl.c
  group vsf/component/ui/tgui/port/view
    ../../vsf/source/component/ui/tgui/port/view/: vsf_tgui_sv_port.c vsf_tgui_sv_port.h
  group vsf/component/ui/tgui/utilities
    ../../vsf/source/component/ui/tgui/utilities/: vsf_tgui_text.c vsf_tgui_text.h
  group vsf/component/ui/tgui/view
    ../../vsf/source/component/ui/tgui/view/: vsf_tgui_v.c vsf_tgui_v.h
  group vsf/component/ui/tgui/view/scgui_view
    ../../vsf/source/component/ui/tgui/view/scgui_view/: lvgl.h scgui.c scgui.h vsf_tgui_scguiv_button.c vsf_tgui_scguiv_button.h vsf_tgui_scguiv_container.c vsf_tgui_scguiv_container.h vsf_tgui_scguiv_control.c vsf_tgui_scguiv_control.h vsf_tgui_scguiv_label.c vsf_tgui_scguiv_label.h vsf_tgui_scguiv_list.c vsf_tgui_scguiv_list.h vsf_tgui_scguiv_panel.c vsf_tgui_scguiv_panel.h vsf_tgui_scguiv_port.c vsf_tgui_scguiv_port.h vsf_tgui_scguiv_text_list.c vsf_tgui_scguiv_text_list.h vsf_tgui_v_template.h vsf_tgui_v_type.h
  group vsf/component/ui/tgui/view/simple_view
    ../../vsf/source/component/ui/tgui/view/simple_view/: vsf_tgui_sv_button.c vsf_tgui_sv_button.h vsf_tgui_sv_color.c vsf_tgui_sv_color.h vsf_tgui_sv_container.c vsf_tgui_sv_container.h vsf_tgui_sv_control.c vsf_tgui_sv_control.h vsf_tgui_sv_draw.c vsf_tgui_sv_draw.h vsf_tgui_sv_label.c vsf_tgui_sv_label.h vsf_tgui_sv_list.c vsf_tgui_sv_list.h vsf_tgui_sv_panel.c vsf_tgui_sv_panel.h vsf_tgui_sv_port.h vsf_tgui_sv_style.c vsf_tgui_sv_style.h vsf_tgui_sv_text_list.c vsf_tgui_sv_text_list.h vsf_tgui_v_template.h vsf_tgui_v_type.h
  group vsf/component/usb
    ../../vsf/source/component/usb/: vsf_usb.h vsf_usb_cfg.h
  group vsf/component/usb/common
    ../../vsf/source/component/usb/common/: usb_common.h usb_desc.h
  group vsf/component/usb/common/class/CDC
    ../../vsf/source/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h vsf_usb_CDCECM.h vsf_usb_CDCNCM.h
  group vsf/component/usb/common/class/HID
    ../../vsf/source/component/usb/common/class/HID/: vsf_usb_ds4.h vsf_usb_HID.h vsf_usb_nspro.h vsf_usb_xb360.h
  group vsf/component/usb/common/class/MSC
    ../../vsf/source/component/usb/common/class/MSC/: vsf_usb_MSC.h
  group vsf/component/usb/common/class/UAC
    ../../vsf/source/component/usb/common/class/UAC/: vsf_usb_UAC.h
  group vsf/component/usb/common/class/UVC
    ../../vsf/source/component/usb/common/class/UVC/: vsf_usb_UVC.h
  group vsf/component/usb/common/class/XB1
    ../../vsf/source/component/usb/common/class/XB1/: vsf_usb_xb1.h
  group vsf/component/usb/device
    ../../vsf/source/component/usb/device/: vsf_usbd.c vsf_usbd.h
  group vsf/component/usb/device/class/CDC
    ../../vsf/source/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h vsf_usbd_CDCACM_desc.h vsf_usbd_CDCNCM.c vsf_usbd_CDCNCM.h vsf_usbd_CDCNCM_desc.h
  group vsf/component/usb/device/class/DFU
    ../../vsf/source/component/usb/device/class/DFU/: vsf_usbd_DFU.c vsf_usbd_DFU.h vsf_usbd_DFU_desc.h
  group vsf/component/usb/device/class/HID
    ../../vsf/source/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h vsf_usbd_HID_desc.h vsf_usbd_hidmsc.c vsf_usbd_hidmsc.h
  group vsf/component/usb/device/class/MSC
    ../../vsf/source/component/usb/device/class/MSC/: vsf_usbd_MSC.c vsf_usbd_MSC.h vsf_usbd_MSC_desc.h
  group vsf/component/usb/device/class/UAC
    ../../vsf/source/component/usb/device/class/UAC/: vsf_usbd_UAC.c vsf_usbd_UAC.h
  group vsf/component/usb/device/class/UVC
    ../../vsf/source/component/usb/device/class/UVC/: vsf_usbd_UVC.c vsf_usbd_UVC.h
  group vsf/component/usb/driver/dcd/usbip_dcd
    ../../vsf/source/component/usb/driver/dcd/usbip_dcd/: vsf_usbip_dcd.c vsf_usbip_dcd.h
  group vsf/component/usb/driver/dcd/usbip_dcd/backend
    ../../vsf/source/component/usb/driver/dcd/usbip_dcd/backend/: vsf_usbip_dcd_lwip.c vsf_usbip_dcd_win.c
  group vsf/component/usb/driver/hcd/ohci
    ../../vsf/source/component/usb/driver/hcd/ohci/: vsf_ohci.c vsf_ohci.h
  group vsf/component/usb/driver/otg/dwcotg
    ../../vsf/source/component/usb/driver/otg/dwcotg/: dwcotg_regs.h vsf_dwcotg_common.c vsf_dwcotg_common.h vsf_dwcotg_dcd.c vsf_dwcotg_dcd.h vsf_dwcotg_hcd.c vsf_dwcotg_hcd.h vsf_dwcotg_hw.h
  group vsf/component/usb/driver/otg/musb/fdrc
    ../../vsf/source/component/usb/driver/otg/musb/fdrc/: __vsf_musb_fdrc_common.c __vsf_musb_fdrc_common.h vsf_musb_fdrc_dcd.c vsf_musb_fdrc_dcd.h vsf_musb_fdrc_hcd.c vsf_musb_fdrc_hcd.h
  group vsf/component/usb/host
    ../../vsf/source/component/usb/host/: vsf_usbh.c vsf_usbh.h
  group vsf/component/usb/host/class/BTHCI
    ../../vsf/source/component/usb/host/class/BTHCI/: vsf_usbh_BTHCI.c vsf_usbh_BTHCI.h
  group vsf/component/usb/host/class/CDC
    ../../vsf/source/component/usb/host/class/CDC/: vsf_usbh_CDC.c vsf_usbh_CDC.h vsf_usbh_CDCECM.c vsf_usbh_CDCECM.h
  group vsf/component/usb/host/class/DL1x5
    ../../vsf/source/component/usb/host/class/DL1x5/: vsf_usbh_dl1x5.c vsf_usbh_dl1x5.h
  group vsf/component/usb/host/class/HID
    ../../vsf/source/component/usb/host/class/HID/: vsf_usbh_ds4.c vsf_usbh_ds4.h vsf_usbh_HID.c vsf_usbh_HID.h vsf_usbh_nspro.c vsf_usbh_nspro.h vsf_usbh_xb360.c vsf_usbh_xb360.h
  group vsf/component/usb/host/class/HUB
    ../../vsf/source/component/usb/host/class/HUB/: vsf_usbh_HUB.c vsf_usbh_HUB.h
  group vsf/component/usb/host/class/libusb
    ../../vsf/source/component/usb/host/class/libusb/: vsf_usbh_libusb.c vsf_usbh_libusb.h
  group vsf/component/usb/host/class/MSC
    ../../vsf/source/component/usb/host/class/MSC/: vsf_usbh_msc.c vsf_usbh_msc.h
  group vsf/component/usb/host/class/UAC
    ../../vsf/source/component/usb/host/class/UAC/: vsf_usbh_uac.c vsf_usbh_uac.h
  group vsf/component/usb/host/class/UVC
    ../../vsf/source/component/usb/host/class/UVC/: vsf_usbh_uvc.c vsf_usbh_uvc.h
  group vsf/component/usb/host/class/XB1
    ../../vsf/source/component/usb/host/class/XB1/: vsf_usbh_xb1.c vsf_usbh_xb1.h
  group vsf/hal
    ../../vsf/source/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../vsf/source/hal/arch/: __vsf_arch_interface.h vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group vsf/hal/arch/arm/arm9
    ../../vsf/source/hal/arch/arm/arm9/: arm9_generic.c arm9_generic.h
  group vsf/hal/arch/arm/arm9/startup
    ../../vsf/source/hal/arch/arm/arm9/startup/app/asm/iar/: entry.S
  group vsf/hal/arch/arm/cortex-a
    ../../vsf/source/hal/arch/arm/cortex-a/: cortex_a_generic.c cortex_a_generic.h
  group vsf/hal/arch/arm/cortex-m
    ../../vsf/source/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group vsf/hal/arch/arm/cortex-m/systick
    ../../vsf/source/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal/driver
    ../../vsf/source/hal/driver/: driver.h
  group vsf/hal/driver/AIC
    ../../vsf/source/hal/driver/AIC/: driver.h
  group vsf/hal/driver/AIC/AIC8800
    ../../vsf/source/hal/driver/AIC/AIC8800/: __device.h common.h device.h driver.c driver.h startup_AIC8800.c
  group vsf/hal/driver/AIC/AIC8800/adc
    ../../vsf/source/hal/driver/AIC/AIC8800/adc/: adc.c adc.h
  group vsf/hal/driver/AIC/AIC8800/debug_uart
    ../../vsf/source/hal/driver/AIC/AIC8800/debug_uart/: debug_uart.c debug_uart.h
  group vsf/hal/driver/AIC/AIC8800/flash
    ../../vsf/source/hal/driver/AIC/AIC8800/flash/: flash.c flash.h
  group vsf/hal/driver/AIC/AIC8800/gpio
    ../../vsf/source/hal/driver/AIC/AIC8800/gpio/: gpio.c gpio.h
  group vsf/hal/driver/AIC/AIC8800/i2c
    ../../vsf/source/hal/driver/AIC/AIC8800/i2c/: i2c.c i2c.h
  group vsf/hal/driver/AIC/AIC8800/i2s
    ../../vsf/source/hal/driver/AIC/AIC8800/i2s/: i2s.c i2s.h
  group vsf/hal/driver/AIC/AIC8800/port
    ../../vsf/source/hal/driver/AIC/AIC8800/port/: compiler.h
  group vsf/hal/driver/AIC/AIC8800/port/arch/ll
    ../../vsf/source/hal/driver/AIC/AIC8800/port/arch/ll/: ll.c ll.h
  group vsf/hal/driver/AIC/AIC8800/port/bt/btstack
    ../../vsf/source/hal/driver/AIC/AIC8800/port/bt/btstack/: hci_transport_aic8800.c
  group vsf/hal/driver/AIC/AIC8800/port/lwip
    ../../vsf/source/hal/driver/AIC/AIC8800/port/lwip/: lwip_forward_compatibility.c
  group vsf/hal/driver/AIC/AIC8800/port/mbedtls
    ../../vsf/source/hal/driver/AIC/AIC8800/port/mbedtls/: mbedtls_aic8800.c mbedtls_aic8800.h
  group vsf/hal/driver/AIC/AIC8800/port/rtos
    ../../vsf/source/hal/driver/AIC/AIC8800/port/rtos/: rtos.h rtos_al.c rtos_al.h
  group vsf/hal/driver/AIC/AIC8800/sdio
    ../../vsf/source/hal/driver/AIC/AIC8800/sdio/: sdio.c sdio.h
  group vsf/hal/driver/AIC/AIC8800/spi
    ../../vsf/source/hal/driver/AIC/AIC8800/spi/: i_reg_spi.h spi.c spi.h
  group vsf/hal/driver/AIC/AIC8800/trng
    ../../vsf/source/hal/driver/AIC/AIC8800/trng/: trng.c trng.h
  group vsf/hal/driver/AIC/AIC8800/uart
    ../../vsf/source/hal/driver/AIC/AIC8800/uart/: i_reg_uart.h uart.c uart.h
  group vsf/hal/driver/AIC/AIC8800/usb
    ../../vsf/source/hal/driver/AIC/AIC8800/usb/: usb.c usb.h usb_common.c usb_lv0.c
  group vsf/hal/driver/AIC/AIC8800/usb/dc
    ../../vsf/source/hal/driver/AIC/AIC8800/usb/dc/: usbd.c usbd.h
  group vsf/hal/driver/AIC/AIC8800/usb/hc
    ../../vsf/source/hal/driver/AIC/AIC8800/usb/hc/: usbh.c usbh.h
  group vsf/hal/driver/AIC/AIC8800/vendor/audio/asio
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/audio/asio/: asio.c asio.h asio_dsd.c asio_dsd.h asio_src.c asio_src.h
  group vsf/hal/driver/AIC/AIC8800/vendor/audio/common
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/audio/common/: audio_config.c audio_config.h audio_mem.h audio_tws.h audio_types.h audio_utils.c audio_utils.h rt_mem.c rt_mem.h
  group vsf/hal/driver/AIC/AIC8800/vendor/audio/device
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/audio/device/: aic1000_psi_api.c aic1000_psi_api.h codec_ext_aic1000.c
  group vsf/hal/driver/AIC/AIC8800/vendor/audio/lib
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/audio/lib/armgcc_4_8/: libaudio_lite.a
  group vsf/hal/driver/AIC/AIC8800/vendor/audio/process/audio_proc
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/audio/process/audio_proc/: audio_proc_api.c audio_proc_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/audio/process/drc
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/audio/process/drc/: audio_drc.c audio_drc.h audio_drc_cmd.c
  group vsf/hal/driver/AIC/AIC8800/vendor/audio/process/eq
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/audio/process/eq/: audio_eq.c audio_eq.h audio_eq_cmd.c
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/dhcps
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/dhcps/: dhcps.c dhcps.h
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2/ports/rtos
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2_RELEASE_VER/ports/rtos/: sys_arch.c
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2/ports/rtos/include/arch
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2_RELEASE_VER/ports/rtos/include/arch/: bpstruct.h cc.h epstruct.h perf.h sys_arch.h
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2/src/api
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2_RELEASE_VER/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2/src/apps/mdns
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2_RELEASE_VER/src/apps/mdns/: mdns.c
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2/src/core
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2_RELEASE_VER/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2/src/core/ipv4
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2_RELEASE_VER/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2/src/core/ipv6
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2_RELEASE_VER/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2/src/netif
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/lwip-STABLE-2_0_2_RELEASE_VER/src/netif/: ethernet.c
  group vsf/hal/driver/AIC/AIC8800/vendor/lwip/net_al
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/lwip/net_al/: lwiphooks.h lwipopts.h net_al.c net_al.h net_def.h net_iperf_al.c net_iperf_al.h net_tg_al.c net_tg_al.h
  group vsf/hal/driver/AIC/AIC8800/vendor/modules/common/api
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/modules/common/api/: co_bool.h co_dlist.h co_endian.h co_int.h co_list.h co_math.h co_pool.h co_ring.h co_status.h co_utils.h
  group vsf/hal/driver/AIC/AIC8800/vendor/modules/common/src
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/modules/common/src/: co_dlist.c co_list.c co_math.c co_pool.c co_ring.c
  group vsf/hal/driver/AIC/AIC8800/vendor/modules/dbg/api
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/modules/dbg/api/: dbg.h dbg_assert.h
  group vsf/hal/driver/AIC/AIC8800/vendor/modules/dbg/src
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/modules/dbg/src/: dbg.c dbg_assert.c dbg_print.c
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/lib
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/lib/armgcc_4_8/: libdrv_lite.a
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/arch
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/arch/: arch.h plf.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/: chip.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/aic1000lite_regs
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/aic1000lite_regs/: aic1000Lite_analog_reg.h aic1000Lite_iomux.h aic1000Lite_sys_ctrl.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/asdma_mst
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/asdma_mst/: asdma_mst_api.h asdma_mst_api2.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/aud_proc
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/aud_proc/: aud_proc.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/bt
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/bt/: bt_common_config.c bt_hci.h bt_patch_table.c bt_patch_table.h bt_user_driver.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/bt/patch/mcu
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/bt/patch/mcu/: fw_patch_table_u02.c fw_patch_table_u02.h fw_patch_table_u03.c fw_patch_table_u03.h fw_patch_u02.c fw_patch_u02.h fw_patch_u03.c fw_patch_u03.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/ce
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/ce/: ce_api.h ce_common.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/common
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/common/: dma_common.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/dma
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/dma/: dma_api.h dma_api_bt.h dma_generic.h reg_dma.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/flash
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/flash/: flash_api.c flash_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/i2cm
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/i2cm/: reg_i2cm.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/iomux
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/iomux/: reg_iomux.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/ipc
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/ipc/: reg_g1_ipc_app.h reg_g1_ipc_emb.h reg_ipc_app.h reg_ipc_comreg.h reg_ipc_mutex.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/pmic
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/pmic/: pmic_api.h pwrkey_api.c pwrkey_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/reg
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/reg/: reg_access.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/rf
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/rf/: reg_bt_rf.h reg_riu.h reg_wcnaon.h reg_wlan_rf.h rf_config.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/sdmmc
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/sdmmc/: reg_sdmmc.h sdmmc_api.c sdmmc_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/sleep
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/sleep/: sleep_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/spi
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/spi/: reg_spi.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/stdio_uart
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/stdio_uart/: reg_stdio_uart.h stdio_uart.c stdio_uart.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/sysctrl
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/sysctrl/: reg_sysctrl.h sysctrl_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/ticker
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/ticker/: lp_ticker.c lp_ticker_api.c lp_ticker_api.h reg_timer.h ticker_api.c ticker_api.h us_ticker.c us_ticker_api.c us_ticker_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/time
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/time/: time_api.c time_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/trans
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/trans/: arm_bitreversal2.S arm_cfft_q15.c arm_cfft_radix4_q15.c arm_common_tables.h trans_api.h trans_common.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/trng
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/trng/: reg_trng.h trng_api.c trng_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/uart
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/uart/: reg_uart1.h reg_uart2.h uart1_api.c uart1_api.h uart2_api.c uart2_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/wdt
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/plf/aic8800/src/driver/wdt/: reg_wdt.h wdt_api.c wdt_api.h
  group vsf/hal/driver/AIC/AIC8800/vendor/wifi/fhost
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/wifi/fhost/: cfgrwnx.h fhost.h fhost_api.h fhost_cntrl.h fhost_config.c fhost_config.h fhost_rtos.h fhost_rx_def.h fhost_tx.h fhost_wpa.h
  group vsf/hal/driver/AIC/AIC8800/vendor/wifi/lib
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/wifi/lib/armgcc_4_8/: libwifi.a
  group vsf/hal/driver/AIC/AIC8800/vendor/wifi/macif
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/wifi/macif/: rom_patch.c
  group vsf/hal/driver/AIC/AIC8800/vendor/wpa_supplicant/lib
    ../../vsf/source/hal/driver/AIC/AIC8800/vendor/wpa_supplicant/lib/armgcc_4_8/: libwpa.a
  group vsf/hal/driver/Allwinner
    ../../vsf/source/hal/driver/Allwinner/: driver.h
  group vsf/hal/driver/Allwinner/F1CX00S
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/: __device.h
  group vsf/hal/driver/Allwinner/F1CX00S/common
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/: __common.c __common.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/debug_uart
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/debug_uart/: debug_uart.c debug_uart.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/dram
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/dram/: dram.c dram.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/fb
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/fb/: fb.c fb.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/intc
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/intc/: i_reg_inc.h intc.c intc.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/rtp
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/rtp/: mean.c mean.h median.c median.h rtp.c rtp.h tsfilter.c tsfilter.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/uart
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/uart/: uart.c uart.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/usb
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/usb/: usb.c usb.h usb_common.c
  group vsf/hal/driver/Allwinner/F1CX00S/common/usb/dc
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/usb/dc/: usbd.c usbd.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/usb/hc
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/common/usb/hc/: usbh.c usbh.h
  group vsf/hal/driver/Allwinner/F1CX00S/F1C100S
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/F1C100S/: device.h driver.c driver.h f1c100s_reg.h interrupt_swi.c interrupt_swi.h
  group vsf/hal/driver/Allwinner/F1CX00S/F1C100S/startup
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/F1C100S/startup/app/: startup_F1C100S.c
  group vsf/hal/driver/Allwinner/F1CX00S/F1C100S/startup/asm
    ../../vsf/source/hal/driver/Allwinner/F1CX00S/F1C100S/startup/app/asm/iar/: startup.S
  group vsf/hal/driver/arm
    ../../vsf/source/hal/driver/arm/: driver.h
  group vsf/hal/driver/arm/mps2
    ../../vsf/source/hal/driver/arm/mps2/: __device.h driver.h
  group vsf/hal/driver/arm/mps2/CMSDK_CM0
    ../../vsf/source/hal/driver/arm/mps2/CMSDK_CM0/: device.h driver.c driver.h startup_ARMCM0.c
  group vsf/hal/driver/arm/mps2/CMSDK_CM7
    ../../vsf/source/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.c driver.h startup_ARMCM7.c
  group vsf/hal/driver/arm/mps2/common
    ../../vsf/source/hal/driver/arm/mps2/common/: __common.c __common.h
  group vsf/hal/driver/Artery
    ../../vsf/source/hal/driver/Artery/: driver.h
  group vsf/hal/driver/Artery/AT32F402_405
    ../../vsf/source/hal/driver/Artery/AT32F402_405/: __device.h
  group vsf/hal/driver/Artery/AT32F402_405/AT32F405KCU7_4
    ../../vsf/source/hal/driver/Artery/AT32F402_405/AT32F405KCU7_4/: device.h
  group vsf/hal/driver/Artery/AT32F402_405/common
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/: at32f402_405_conf.h common.h device.h device_af.h device_irq.h driver.c driver.h startup_AT32F402_405.c
  group vsf/hal/driver/Artery/AT32F402_405/common/exti
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/exti/: exti.c exti.h
  group vsf/hal/driver/Artery/AT32F402_405/common/flash
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/flash/: flash.c flash.h
  group vsf/hal/driver/Artery/AT32F402_405/common/gpio
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/gpio/: gpio.c gpio.h
  group vsf/hal/driver/Artery/AT32F402_405/common/i2c
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/i2c/: i2c.c i2c.h
  group vsf/hal/driver/Artery/AT32F402_405/common/spi
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/spi/: spi.c spi.h
  group vsf/hal/driver/Artery/AT32F402_405/common/usart
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/usart/: usart.c usart.h
  group vsf/hal/driver/Artery/AT32F402_405/common/usb
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/usb/: usb.c usb.h usb_common.c usb_lv0.c
  group vsf/hal/driver/Artery/AT32F402_405/common/usb/dc
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/usb/dc/: usbd.c usbd.h
  group vsf/hal/driver/Artery/AT32F402_405/common/usb/hc
    ../../vsf/source/hal/driver/Artery/AT32F402_405/common/usb/hc/: usbh.c usbh.h
  group vsf/hal/driver/common
    ../../vsf/source/hal/driver/common/: common.h
  group vsf/hal/driver/common/adc
    ../../vsf/source/hal/driver/common/adc/: adc_common.c adc_template.h
  group vsf/hal/driver/common/flash
    ../../vsf/source/hal/driver/common/flash/: flash_common.c flash_template.h
  group vsf/hal/driver/common/gpio
    ../../vsf/source/hal/driver/common/gpio/: exti_gpio.c exti_gpio.h gpio_common.c gpio_template.h
  group vsf/hal/driver/common/i2c
    ../../vsf/source/hal/driver/common/i2c/: i2c_common.c i2c_request.c i2c_request.h i2c_template.inc multiplex_i2c.c multiplex_i2c.h
  group vsf/hal/driver/common/i2s
    ../../vsf/source/hal/driver/common/i2s/: i2s_common.c i2s_template.h i2s_template.inc
  group vsf/hal/driver/common/pm
    ../../vsf/source/hal/driver/common/pm/: pm_template.h
  group vsf/hal/driver/common/pwm
    ../../vsf/source/hal/driver/common/pwm/: pwm_common.c pwm_template.h
  group vsf/hal/driver/common/rng
    ../../vsf/source/hal/driver/common/rng/: rng_common.c rng_template.h
  group vsf/hal/driver/common/rtc
    ../../vsf/source/hal/driver/common/rtc/: rtc_common.c rtc_common.h rtc_template.h
  group vsf/hal/driver/common/sdio
    ../../vsf/source/hal/driver/common/sdio/: sdio_common.c sdio_probe.c sdio_probe.h sdio_template.h
  group vsf/hal/driver/common/spi
    ../../vsf/source/hal/driver/common/spi/: multiplex_spi.c multiplex_spi.h spi_common.c spi_template.inc
  group vsf/hal/driver/common/swi
    ../../vsf/source/hal/driver/common/swi/: vsf_swi_template.h
  group vsf/hal/driver/common/swi/arm
    ../../vsf/source/hal/driver/common/swi/arm/: vsf_swi_template.inc
  group vsf/hal/driver/common/template
    ../../vsf/source/hal/driver/common/template/: vsf_template.h vsf_template_adc.h vsf_template_declaration.h vsf_template_flash.h vsf_template_gpio.h vsf_template_hal_driver.h vsf_template_i2c.h vsf_template_i2s.h vsf_template_implementation.h vsf_template_mmc.h vsf_template_pm.h vsf_template_pwm.h vsf_template_rng.h vsf_template_rtc.h vsf_template_sdio.h vsf_template_spi.h vsf_template_timer.h vsf_template_usart.h vsf_template_usb.h
  group vsf/hal/driver/common/timer
    ../../vsf/source/hal/driver/common/timer/: timer_common.c timer_template.h
  group vsf/hal/driver/common/usart
    ../../vsf/source/hal/driver/common/usart/: fifo2req_usart.c fifo2req_usart.h usart_common.c usart_template.inc vsf_drv_usart_poll_util.h
  group vsf/hal/driver/GigaDevice
    ../../vsf/source/hal/driver/GigaDevice/: driver.h
  group vsf/hal/driver/GigaDevice/GD32E10X
    ../../vsf/source/hal/driver/GigaDevice/GD32E10X/: __device.h
  group vsf/hal/driver/GigaDevice/GD32E10X/common
    ../../vsf/source/hal/driver/GigaDevice/GD32E10X/common/: __common.c __common.h
  group vsf/hal/driver/GigaDevice/GD32E10X/common/usb
    ../../vsf/source/hal/driver/GigaDevice/GD32E10X/common/usb/: usb.c usb.h usb_common.c usb_lv0.c
  group vsf/hal/driver/GigaDevice/GD32E10X/common/usb/dc
    ../../vsf/source/hal/driver/GigaDevice/GD32E10X/common/usb/dc/: usbd.c usbd.h
  group vsf/hal/driver/GigaDevice/GD32E10X/common/usb/hc
    ../../vsf/source/hal/driver/GigaDevice/GD32E10X/common/usb/hc/: usbh.c usbh.h
  group vsf/hal/driver/GigaDevice/GD32E10X/common/vendor/Include
    ../../vsf/source/hal/driver/GigaDevice/GD32E10X/common/vendor/Include/: gd32e10x.h gd32e10x_adc.h gd32e10x_bkp.h gd32e10x_can.h gd32e10x_crc.h gd32e10x_ctc.h gd32e10x_dac.h gd32e10x_dbg.h gd32e10x_dma.h gd32e10x_exmc.h gd32e10x_exti.h gd32e10x_fmc.h gd32e10x_fwdgt.h gd32e10x_gpio.h gd32e10x_i2c.h gd32e10x_misc.h gd32e10x_pmu.h gd32e10x_rcu.h gd32e10x_rtc.h gd32e10x_spi.h gd32e10x_timer.h gd32e10x_usart.h gd32e10x_wwdgt.h
  group vsf/hal/driver/GigaDevice/GD32E10X/GD32E103
    ../../vsf/source/hal/driver/GigaDevice/GD32E10X/GD32E103/: device.h driver.c driver.h startup_gd32e103.c
  group vsf/hal/driver/GigaDevice/GD32H7XX
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/: __device.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/: common.h driver.c driver.h startup_gd32h7xx.c
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/fb
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/fb/: fb.c fb.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/flash
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/flash/: flash.c flash.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/gpio
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/gpio/: gpio.c gpio.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/sdio
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/sdio/: sdio.c sdio.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/usart
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/usart/: usart.c usart.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/usb
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/usb/: usb.c usb.h usb_common.c usb_lv0.c usb_priv.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/usb/dc
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/usb/dc/: usbd.c usbd.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/usb/hc
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/usb/hc/: usbh.c usbh.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/vendor/Include
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/vendor/Include/: gd32h7xx.h gd32h7xx_adc.h gd32h7xx_axiim.h gd32h7xx_can.h gd32h7xx_cau.h gd32h7xx_cmp.h gd32h7xx_cpdm.h gd32h7xx_crc.h gd32h7xx_ctc.h gd32h7xx_dac.h gd32h7xx_dbg.h gd32h7xx_dci.h gd32h7xx_dma.h gd32h7xx_edout.h gd32h7xx_efuse.h gd32h7xx_enet.h gd32h7xx_exmc.h gd32h7xx_exti.h gd32h7xx_fac.h gd32h7xx_fmc.h gd32h7xx_fwdgt.h gd32h7xx_gpio.h gd32h7xx_hau.h gd32h7xx_hpdf.h gd32h7xx_hwsem.h gd32h7xx_i2c.h gd32h7xx_ipa.h gd32h7xx_lpdts.h gd32h7xx_mdio.h gd32h7xx_mdma.h gd32h7xx_misc.h gd32h7xx_ospi.h gd32h7xx_ospim.h gd32h7xx_pmu.h gd32h7xx_rameccmu.h gd32h7xx_rcu.h gd32h7xx_rspdif.h gd32h7xx_rtc.h gd32h7xx_rtdec.h gd32h7xx_sai.h gd32h7xx_sdio.h gd32h7xx_spi.h gd32h7xx_syscfg.h gd32h7xx_timer.h gd32h7xx_tli.h gd32h7xx_tmu.h gd32h7xx_trigsel.h gd32h7xx_trng.h gd32h7xx_usart.h gd32h7xx_vref.h gd32h7xx_wwdgt.h system_gd32h7xx.h
  group vsf/hal/driver/GigaDevice/GD32H7XX/common/vendor/Source
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/common/vendor/Source/: gd32h7xx_exmc.c system_gd32h7xx.c
  group vsf/hal/driver/GigaDevice/GD32H7XX/GD32H759
    ../../vsf/source/hal/driver/GigaDevice/GD32H7XX/GD32H759/: device.h
  group vsf/hal/driver/Nations
    ../../vsf/source/hal/driver/Nations/: driver.h
  group vsf/hal/driver/Nations/N32H76X_78X
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/: __device.h
  group vsf/hal/driver/Nations/N32H76X_78X/common
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/: common.h device_af.h device_irq.h driver.c driver.h startup_n32h76x_78x.c
  group vsf/hal/driver/Nations/N32H76X_78X/common/flash
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/flash/: flash.c flash.h
  group vsf/hal/driver/Nations/N32H76X_78X/common/gpio
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/gpio/: gpio.c gpio.h
  group vsf/hal/driver/Nations/N32H76X_78X/common/i2c
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/i2c/: i2c.c i2c.h
  group vsf/hal/driver/Nations/N32H76X_78X/common/sdio
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/sdio/: sdio.c sdio.h
  group vsf/hal/driver/Nations/N32H76X_78X/common/spi
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/spi/: spi.c spi.h
  group vsf/hal/driver/Nations/N32H76X_78X/common/usart
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/usart/: usart.c usart.h
  group vsf/hal/driver/Nations/N32H76X_78X/common/usb
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/usb/: usb.c usb.h usb_common.c usb_lv0.c
  group vsf/hal/driver/Nations/N32H76X_78X/common/usb/dc
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/usb/dc/: usbd.c usbd.h
  group vsf/hal/driver/Nations/N32H76X_78X/common/usb/hc
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/usb/hc/: usbh.c usbh.h
  group vsf/hal/driver/Nations/N32H76X_78X/common/vendor
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/common/vendor/: n32h76x_78x.h system_n32h76x_78x.h
  group vsf/hal/driver/Nations/N32H76X_78X/N32H765IIB7EC
    ../../vsf/source/hal/driver/Nations/N32H76X_78X/N32H765IIB7EC/: device.h
  group vsf/hal/driver/Nuvoton
    ../../vsf/source/hal/driver/Nuvoton/: driver.h
  group vsf/hal/driver/Nuvoton/M480
    ../../vsf/source/hal/driver/Nuvoton/M480/: __device.h
  group vsf/hal/driver/Nuvoton/M480/common
    ../../vsf/source/hal/driver/Nuvoton/M480/common/: __common.c __common.h
  group vsf/hal/driver/Nuvoton/M480/common/dma
    ../../vsf/source/hal/driver/Nuvoton/M480/common/dma/: dma.c dma.h
  group vsf/hal/driver/Nuvoton/M480/common/io
    ../../vsf/source/hal/driver/Nuvoton/M480/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/pm
    ../../vsf/source/hal/driver/Nuvoton/M480/common/pm/: pm.c pm.h pm_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/spi
    ../../vsf/source/hal/driver/Nuvoton/M480/common/spi/: spi.c spi.h
  group vsf/hal/driver/Nuvoton/M480/common/usart
    ../../vsf/source/hal/driver/Nuvoton/M480/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb
    ../../vsf/source/hal/driver/Nuvoton/M480/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb/dc
    ../../vsf/source/hal/driver/Nuvoton/M480/common/usb/dc/: usbd_hs.c usbd_hs.h
  group vsf/hal/driver/Nuvoton/M480/common/usb/ohci
    ../../vsf/source/hal/driver/Nuvoton/M480/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/Include
    ../../vsf/source/hal/driver/Nuvoton/M480/common/vendor/Include/: acmp_reg.h bpwm_reg.h can_reg.h clk_reg.h crc_reg.h crypto_reg.h dac_reg.h eadc_reg.h ebi_reg.h ecap_reg.h emac_reg.h epwm_reg.h fmc_reg.h gpio_reg.h hsotg_reg.h hsusbd_reg.h hsusbh_reg.h i2c_reg.h i2s_reg.h M480.h NuMicro.h opa_reg.h otg_reg.h pdma_reg.h qei_reg.h qspi_reg.h rtc_reg.h sc_reg.h sdh_reg.h spi_reg.h spim_reg.h sys_reg.h system_M480.h timer_reg.h uart_reg.h ui2c_reg.h usbd_reg.h usbh_reg.h uspi_reg.h uuart_reg.h wdt_reg.h wwdt_reg.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/startup
    ../../vsf/source/hal/driver/Nuvoton/M480/common/vendor/startup/IAR/: startup_M480.s.template
  group vsf/hal/driver/Nuvoton/M480/M484
    ../../vsf/source/hal/driver/Nuvoton/M480/M484/: device.h driver.c driver.h interrupt_swi.c interrupt_swi.h startup_M484.c
  group vsf/hal/driver/Nuvoton/NUC500
    ../../vsf/source/hal/driver/Nuvoton/NUC500/: __device.h
  group vsf/hal/driver/Nuvoton/NUC500/common/usb
    ../../vsf/source/hal/driver/Nuvoton/NUC500/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/NUC500/common/usb/ohci
    ../../vsf/source/hal/driver/Nuvoton/NUC500/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/NUC500/NUC505
    ../../vsf/source/hal/driver/Nuvoton/NUC500/NUC505/: device.h driver.c driver.h startup_NUC505.c
  group vsf/hal/driver/Nuvoton/NUC500/NUC505/vendor/Include
    ../../vsf/source/hal/driver/Nuvoton/NUC500/NUC505/vendor/Include/: NUC505Series.h
  group vsf/hal/driver/SiFli
    ../../vsf/source/hal/driver/SiFli/: __device.h driver.h
  group vsf/hal/driver/SiFli/common/SF32LB5XX
    ../../vsf/source/hal/driver/SiFli/common/SF32LB5XX/: common.c
  group vsf/hal/driver/SiFli/common/SF32LB5XX/usart
    ../../vsf/source/hal/driver/SiFli/common/SF32LB5XX/usart/: vsf_usart.c vsf_usart.h
  group vsf/hal/driver/SiFli/SF32LB52X
    ../../vsf/source/hal/driver/SiFli/SF32LB52X/: __device.h
  group vsf/hal/driver/SiFli/SF32LB52X/common
    ../../vsf/source/hal/driver/SiFli/SF32LB52X/common/: common.h driver.c driver.h startup_sf32lb52x.c
  group vsf/hal/driver/SiFli/SF32LB52X/common/flash
    ../../vsf/source/hal/driver/SiFli/SF32LB52X/common/flash/: flash.c flash.h
  group vsf/hal/driver/SiFli/SF32LB52X/SF32LB520U36
    ../../vsf/source/hal/driver/SiFli/SF32LB52X/SF32LB520U36/: device.h
  group vsf/hal/driver/ST
    ../../vsf/source/hal/driver/ST/: driver.h
  group vsf/hal/driver/ST/STM32F103
    ../../vsf/source/hal/driver/ST/STM32F103/: __device.h
  group vsf/hal/driver/ST/STM32F103/STM32F103ZE
    ../../vsf/source/hal/driver/ST/STM32F103/STM32F103ZE/: device.h driver.c driver.h startup_stm32f103xe.s
  group vsf/hal/driver/ST/STM32F730
    ../../vsf/source/hal/driver/ST/STM32F730/: __device.h
  group vsf/hal/driver/ST/STM32F730/common
    ../../vsf/source/hal/driver/ST/STM32F730/common/: __common.c __common.h
  group vsf/hal/driver/ST/STM32F730/common/vendor/Include
    ../../vsf/source/hal/driver/ST/STM32F730/common/vendor/Include/: stm32f730xx.h
  group vsf/hal/driver/ST/STM32F730/STM32F730R8
    ../../vsf/source/hal/driver/ST/STM32F730/STM32F730R8/: device.h driver.c driver.h startup_STM32F730R8.c
  group vsf/hal/driver/ST/STM32H7XX/common
    ../../vsf/source/hal/driver/ST/STM32H7XX/common/: common.h driver.c driver.h startup_STM32H7.c
  group vsf/hal/driver/ST/STM32H7XX/common/flash
    ../../vsf/source/hal/driver/ST/STM32H7XX/common/flash/: flash.c flash.h
  group vsf/hal/driver/ST/STM32H7XX/common/gpio
    ../../vsf/source/hal/driver/ST/STM32H7XX/common/gpio/: gpio.c gpio.h
  group vsf/hal/driver/ST/STM32H7XX/common/sdio
    ../../vsf/source/hal/driver/ST/STM32H7XX/common/sdio/: sdio.c sdio.h
  group vsf/hal/driver/ST/STM32H7XX/common/usart
    ../../vsf/source/hal/driver/ST/STM32H7XX/common/usart/: usart.c usart.h
  group vsf/hal/driver/ST/STM32H7XX/common/vendor/Inc
    ../../vsf/source/hal/driver/ST/STM32H7XX/common/vendor/cmsis_device_h7/Include/: stm32h743xx.h system_stm32h7xx.h
  group vsf/hal/driver/ST/STM32H7XX/common/vendor/Src
    ../../vsf/source/hal/driver/ST/STM32H7XX/common/vendor/cmsis_device_h7/Source/Templates/: system_stm32h7xx.c
  group vsf/hal/driver/ST/STM32H7XX/STM32H743VI
    ../../vsf/source/hal/driver/ST/STM32H7XX/STM32H743VI/: device.h
  group vsf/hal/driver/template
    ../../vsf/source/hal/driver/template/: driver.h
  group vsf/hal/driver/template/__series_name__/__device_name_1__
    ../../vsf/source/hal/driver/template/__series_name__/__device_name_1__/: driver.c driver.h
  group vsf/hal/driver/TI
    ../../vsf/source/hal/driver/TI/: driver.h
  group vsf/hal/driver/TI/AM335X
    ../../vsf/source/hal/driver/TI/AM335X/: __device.h
  group vsf/hal/driver/TI/AM335X/AM3352
    ../../vsf/source/hal/driver/TI/AM335X/AM3352/: device.h driver.c driver.h
  group vsf/hal/driver/unknown
    ../../vsf/source/hal/driver/unknown/: driver.h
  group vsf/hal/driver/unknown/MT071
    ../../vsf/source/hal/driver/unknown/MT071/: __device.h common.h device.h driver.c driver.h startup_mt071.c
  group vsf/hal/driver/unknown/MT071/pm
    ../../vsf/source/hal/driver/unknown/MT071/pm/: pm.h
  group vsf/hal/driver/unknown/MT071/usart
    ../../vsf/source/hal/driver/unknown/MT071/usart/: usart.c usart.h
  group vsf/hal/driver/unknown/MT071/usb
    ../../vsf/source/hal/driver/unknown/MT071/usb/: usb.c usb.h usb_common.c usb_lv0.c
  group vsf/hal/driver/unknown/MT071/usb/dc
    ../../vsf/source/hal/driver/unknown/MT071/usb/dc/: usbd.c usbd.h
  group vsf/hal/driver/unknown/MT071/usb/hc
    ../../vsf/source/hal/driver/unknown/MT071/usb/hc/: usbh.c usbh.h
  group vsf/hal/driver/unknown/MT071/vendor/Include
    ../../vsf/source/hal/driver/unknown/MT071/vendor/Include/: mt071x.h usb_regs.h
  group vsf/hal/driver/vsf
    ../../vsf/source/hal/driver/vsf/: driver.h
  group vsf/hal/driver/vsf/ditbus
    ../../vsf/source/hal/driver/vsf/distbus/: driver.h vsf_hal_distbus.c
  group vsf/hal/driver/vsf/ditbus/adc
    ../../vsf/source/hal/driver/vsf/distbus/adc/: vsf_hal_distbus_adc.c vsf_hal_distbus_adc.h
  group vsf/hal/driver/vsf/ditbus/dac
    ../../vsf/source/hal/driver/vsf/distbus/dac/: vsf_hal_distbus_dac.c vsf_hal_distbus_dac.h
  group vsf/hal/driver/vsf/ditbus/gpio
    ../../vsf/source/hal/driver/vsf/distbus/gpio/: vsf_hal_distbus_gpio.c vsf_hal_distbus_gpio.h
  group vsf/hal/driver/vsf/ditbus/i2c
    ../../vsf/source/hal/driver/vsf/distbus/i2c/: vsf_hal_distbus_i2c.c vsf_hal_distbus_i2c.h
  group vsf/hal/driver/vsf/ditbus/i2s
    ../../vsf/source/hal/driver/vsf/distbus/i2s/: vsf_hal_distbus_i2s.c vsf_hal_distbus_i2s.h
  group vsf/hal/driver/vsf/ditbus/pwm
    ../../vsf/source/hal/driver/vsf/distbus/pwm/: vsf_hal_distbus_pwm.c vsf_hal_distbus_pwm.h
  group vsf/hal/driver/vsf/ditbus/sdio
    ../../vsf/source/hal/driver/vsf/distbus/sdio/: vsf_hal_distbus_sdio.c vsf_hal_distbus_sdio.h
  group vsf/hal/driver/vsf/ditbus/spi
    ../../vsf/source/hal/driver/vsf/distbus/spi/: vsf_hal_distbus_spi.c vsf_hal_distbus_spi.h
  group vsf/hal/driver/vsf/ditbus/usart
    ../../vsf/source/hal/driver/vsf/distbus/usart/: vsf_hal_distbus_usart.c vsf_hal_distbus_usart.h
  group vsf/hal/driver/vsf/ditbus/usbd
    ../../vsf/source/hal/driver/vsf/distbus/usbd/: vsf_hal_distbus_usbd.c vsf_hal_distbus_usbd.h
  group vsf/hal/driver/vsf/ditbus/usbh
    ../../vsf/source/hal/driver/vsf/distbus/usbh/: vsf_hal_distbus_usbh.c vsf_hal_distbus_usbh.h
  group vsf/hal/driver/vsf/gpio/74hc165
    ../../vsf/source/hal/driver/vsf/gpio/74hc165/: vsf_gpio_74hc165.c vsf_gpio_74hc165.h
  group vsf/hal/driver/vsf/i2c/gpio_i2c
    ../../vsf/source/hal/driver/vsf/i2c/gpio_i2c/: vsf_gpio_i2c.c vsf_gpio_i2c.h
  group vsf/hal/driver/WinnerMicro
    ../../vsf/source/hal/driver/WinnerMicro/: driver.h
  group vsf/hal/driver/WinnerMicro/W60X
    ../../vsf/source/hal/driver/WinnerMicro/W60X/: __device.h device.h
  group vsf/hal/driver/WinnerMicro/W60X/common
    ../../vsf/source/hal/driver/WinnerMicro/W60X/common/: common.c common.h
  group vsf/hal/driver/WinnerMicro/W60X/common/io
    ../../vsf/source/hal/driver/WinnerMicro/W60X/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/usart
    ../../vsf/source/hal/driver/WinnerMicro/W60X/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include
    ../../vsf/source/hal/driver/WinnerMicro/W60X/common/vendor/Include/: wm_regs.h
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup
    ../../vsf/source/hal/driver/WinnerMicro/W60X/common/vendor/startup/IAR/: startup_venus.s
  group vsf/hal/driver/WinnerMicro/W60X/W600
    ../../vsf/source/hal/driver/WinnerMicro/W60X/W600/: device.h driver.c driver.h
  group vsf/hal/utilities/io_mapper
    ../../vsf/source/hal/utilities/io_mapper/: vsf_io_mapper.c vsf_io_mapper.h
  group vsf/hal/utilities/remap
    ../../vsf/source/hal/utilities/remap/: vsf_hal_remap.h
  group vsf/hal/utilities/remap/adc
    ../../vsf/source/hal/utilities/remap/adc/: vsf_remapped_adc.c vsf_remapped_adc.h
  group vsf/hal/utilities/remap/dac
    ../../vsf/source/hal/utilities/remap/dac/: vsf_remapped_dac.c vsf_remapped_dac.h
  group vsf/hal/utilities/remap/gpio
    ../../vsf/source/hal/utilities/remap/gpio/: vsf_remapped_gpio.c vsf_remapped_gpio.h
  group vsf/hal/utilities/remap/i2c
    ../../vsf/source/hal/utilities/remap/i2c/: vsf_remapped_i2c.c vsf_remapped_i2c.h
  group vsf/hal/utilities/remap/i2s
    ../../vsf/source/hal/utilities/remap/i2s/: vsf_remapped_i2s.c vsf_remapped_i2s.h
  group vsf/hal/utilities/remap/pwm
    ../../vsf/source/hal/utilities/remap/pwm/: vsf_remapped_pwm.c vsf_remapped_pwm.h
  group vsf/hal/utilities/remap/sdio
    ../../vsf/source/hal/utilities/remap/sdio/: vsf_remapped_sdio.c vsf_remapped_sdio.h
  group vsf/hal/utilities/remap/spi
    ../../vsf/source/hal/utilities/remap/spi/: vsf_remapped_spi.c vsf_remapped_spi.h
  group vsf/hal/utilities/remap/usart
    ../../vsf/source/hal/utilities/remap/usart/: vsf_remapped_usart.c vsf_remapped_usart.h
  group vsf/hal/utilities/stream
    ../../vsf/source/hal/utilities/stream/: vsf_hal_stream.h
  group vsf/hal/utilities/stream/usart
    ../../vsf/source/hal/utilities/stream/usart/: vsf_usart_stream.c vsf_usart_stream.h
  group vsf/kernel
    ../../vsf/source/kernel/: vsf_eda.c vsf_eda.h vsf_eda_slist_queue.c vsf_eda_slist_queue.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
  group vsf/kernel/__eda
    ../../vsf/source/kernel/__eda/: vsf_eda_bmpevt.c vsf_eda_queue.c vsf_eda_sync.c vsf_eda_timer.c
  group vsf/kernel/shell
    ../../vsf/source/kernel/shell/: vsf_shell.c
  group vsf/kernel/shell/simple
    ../../vsf/source/kernel/shell/simple/: vsf_simple.h vsf_simple_bmpevt.c vsf_simple_task.c
  group vsf/kernel/task
    ../../vsf/source/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.c vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/osa_service
    ../../vsf/source/osa_service/: vsf_osa_service.c vsf_osa_service.h vsf_osa_service_cfg.h
  group vsf/osa_service/msg_tree
    ../../vsf/source/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
  group vsf/service
    ../../vsf/source/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group vsf/service/distbus
    ../../vsf/source/service/distbus/: vsf_distbus.c vsf_distbus.h
  group vsf/service/dynarr
    ../../vsf/source/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/service/dynstack
    ../../vsf/source/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/service/fifo
    ../../vsf/source/service/fifo/: vsf_fifo.c vsf_fifo.h
  group vsf/service/heap
    ../../vsf/source/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/service/json
    ../../vsf/source/service/json/: vsf_json.c vsf_json.h
  group vsf/service/loader
    ../../vsf/source/service/loader/: vsf_loader.c vsf_loader.h
  group vsf/service/loader/elf
    ../../vsf/source/service/loader/elf/: elf.h vsf_elfloader.c vsf_elfloader.h
  group vsf/service/loader/elf/arch
    ../../vsf/source/service/loader/elf/arch/: vsf_elfloader_arm.c vsf_elfloader_x64.c
  group vsf/service/pbuf
    ../../vsf/source/service/pbuf/: vsf_pbuf.c vsf_pbuf.h vsf_pbuf_pool.c vsf_pbuf_pool.h
  group vsf/service/pool
    ../../vsf/source/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/simple_stream
    ../../vsf/source/service/simple_stream/: vsf_simple_stream.c vsf_simple_stream.h
  group vsf/service/simple_stream/block_stream
    ../../vsf/source/service/simple_stream/block_stream/: vsf_block_stream.c vsf_block_stream.h
  group vsf/service/simple_stream/distbus_stream
    ../../vsf/source/service/simple_stream/distbus_stream/: vsf_distbus_stream.c vsf_distbus_stream.h
  group vsf/service/simple_stream/fifo_stream
    ../../vsf/source/service/simple_stream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/service/simple_stream/mem_stream
    ../../vsf/source/service/simple_stream/mem_stream/: vsf_mem_stream.c vsf_mem_stream.h
  group vsf/service/simple_stream/queue_stream
    ../../vsf/source/service/simple_stream/queue_stream/: vsf_queue_stream.c vsf_queue_stream.h
  group vsf/service/stream
    ../../vsf/source/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group vsf/service/stream/pbuf_queue
    ../../vsf/source/service/stream/pbuf_queue/: vsf_pbuf_queue.c vsf_pbuf_queue.h
  group vsf/service/trace
    ../../vsf/source/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/shell
    ../../vsf/source/shell/: vsf_shell_wrapper.h
  group vsf/shell/media/sdl2
    ../../vsf/source/shell/media/sdl2/: vsf_sdl2.c vsf_sdl2_cfg.h vsf_sdl2_event.c vsf_sdl2_pixelformat.c
  group vsf/shell/media/sdl2/3rd-party/SDL_image
    ../../vsf/source/shell/media/sdl2/3rd-party/SDL_image/: IMG.c IMG_bmp.c IMG_gif.c IMG_jpg.c IMG_lbm.c IMG_pcx.c IMG_png.c IMG_pnm.c IMG_svg.c IMG_tga.c IMG_tif.c IMG_webp.c IMG_WIC.c IMG_xcf.c IMG_xpm.c IMG_xv.c IMG_xxx.c miniz.h nanosvg.h nanosvgrast.h SDL_image.h
  group vsf/shell/media/sdl2/3rd-party/SDL_ttf
    ../../vsf/source/shell/media/sdl2/3rd-party/SDL_ttf/: SDL_ttf.c SDL_ttf.h
  group vsf/shell/media/sdl2/include
    ../../vsf/source/shell/media/sdl2/include/SDL2/: SDL.h
  group vsf/shell/sys/linux
    ../../vsf/source/shell/sys/linux/: vsf_linux.c vsf_linux.h vsf_linux_cfg.h
  group vsf/shell/sys/linux/app/httpd
    ../../vsf/source/shell/sys/linux/app/httpd/: vsf_linux_httpd.c vsf_linux_httpd.h
  group vsf/shell/sys/linux/app/ntp
    ../../vsf/source/shell/sys/linux/app/ntp/: vsf_linux_ntp.c vsf_linux_ntp.h
  group vsf/shell/sys/linux/app/telnetd
    ../../vsf/source/shell/sys/linux/app/telnetd/: vsf_linux_telnetd.c vsf_linux_telnetd.h
  group vsf/shell/sys/linux/include
    ../../vsf/source/shell/sys/linux/include/: dirent.h err.h errno.h fcntl.h getopt.h grp.h ifaddrs.h libgen.h netdb.h poll.h pthread.h pty.h pwd.h sched.h semaphore.h signal.h syslog.h termios.h unistd.h
  group vsf/shell/sys/linux/include/arpa
    ../../vsf/source/shell/sys/linux/include/arpa/: inet.h
  group vsf/shell/sys/linux/include/libusb
    ../../vsf/source/shell/sys/linux/include/libusb/: libusb.h
  group vsf/shell/sys/linux/include/linux
    ../../vsf/source/shell/sys/linux/include/linux/: atomic.h bitfield.h bits.h delay.h device.h err.h errno.h etherdevice.h fb.h firmware.h fs.h gfp.h hid.h hrtimer.h i2c-dev.h i2c.h idr.h ieee80211.h if_ether.h input.h jiffies.h kobject.h kref.h kstrtox.h leds.h limits.h list.h llist.h minmax.h module.h mutex.h pm.h power_supply.h printk.h refcount.h serial.h skbuff.h slab.h spinlock.h sysfs.h timer.h types.h uinput.h usb.h uuid.h version.h wait.h workqueue.h
  group vsf/shell/sys/linux/include/linux/device
    ../../vsf/source/shell/sys/linux/include/linux/device/: bus.h class.h driver.h
  group vsf/shell/sys/linux/include/linux/spi
    ../../vsf/source/shell/sys/linux/include/linux/spi/: spidev.h
  group vsf/shell/sys/linux/include/linux/usb
    ../../vsf/source/shell/sys/linux/include/linux/usb/: ch9.h
  group vsf/shell/sys/linux/include/net
    ../../vsf/source/shell/sys/linux/include/net/: if.h
  group vsf/shell/sys/linux/include/netinet
    ../../vsf/source/shell/sys/linux/include/netinet/: in.h ip.h tcp.h
  group vsf/shell/sys/linux/include/netpacket
    ../../vsf/source/shell/sys/linux/include/netpacket/: packet.h
  group vsf/shell/sys/linux/include/simple_libc
    ../../vsf/source/shell/sys/linux/include/simple_libc/: ctype.h stddef.h stdio.h stdlib.h string.h time.h wchar.h
  group vsf/shell/sys/linux/include/sys
    ../../vsf/source/shell/sys/linux/include/sys/: epoll.h eventfd.h ioctl.h ipc.h mman.h mount.h param.h random.h resource.h select.h sem.h shm.h signalfd.h socket.h stat.h syscall.h syslog.h time.h times.h types.h uio.h un.h utsname.h wait.h
  group vsf/shell/sys/linux/kernel/core
    ../../vsf/source/shell/sys/linux/kernel/core/: vsf_linux_core.c
  group vsf/shell/sys/linux/kernel/core/80211
    ../../vsf/source/shell/sys/linux/kernel/core/80211/: vsf_linux_core_80211.c
  group vsf/shell/sys/linux/kernel/core/hid
    ../../vsf/source/shell/sys/linux/kernel/core/hid/: vsf_linux_core_hid.c
  group vsf/shell/sys/linux/kernel/core/input
    ../../vsf/source/shell/sys/linux/kernel/core/input/: vsf_linux_core_input.c
  group vsf/shell/sys/linux/kernel/core/led
    ../../vsf/source/shell/sys/linux/kernel/core/led/: vsf_linux_core_led.c
  group vsf/shell/sys/linux/kernel/core/usb
    ../../vsf/source/shell/sys/linux/kernel/core/usb/: vsf_linux_core_usb.c
  group vsf/shell/sys/linux/kernel/fs
    ../../vsf/source/shell/sys/linux/kernel/fs/: vsf_linux_fs.c vsf_linux_fs.h
  group vsf/shell/sys/linux/kernel/fs/vfs
    ../../vsf/source/shell/sys/linux/kernel/fs/vfs/: vsf_linux_vfs.c vsf_linux_vfs.h
  group vsf/shell/sys/linux/kernel/fs/vfs/devfs
    ../../vsf/source/shell/sys/linux/kernel/fs/vfs/devfs/: vsf_linux_devfs.c vsf_linux_devfs.h
  group vsf/shell/sys/linux/kernel/fs/vfs/devfs/alsa
    ../../vsf/source/shell/sys/linux/kernel/fs/vfs/devfs/alsa/: vsf_linux_devfs_alsa.c vsf_linux_devfs_alsa.h
  group vsf/shell/sys/linux/kernel/socket
    ../../vsf/source/shell/sys/linux/kernel/socket/: vsf_linux_socket.c vsf_linux_socket.h
  group vsf/shell/sys/linux/kernel/socket/inet
    ../../vsf/source/shell/sys/linux/kernel/socket/inet/: vsf_linux_socket_inet_lwip.c
  group vsf/shell/sys/linux/kernel/socket/unix
    ../../vsf/source/shell/sys/linux/kernel/socket/unix/: vsf_linux_socket_unix.c
  group vsf/shell/sys/linux/lib/3rd-party/fnmatch
    ../../vsf/source/shell/sys/linux/lib/3rd-party/fnmatch/: fnmatch.c
  group vsf/shell/sys/linux/lib/3rd-party/getopt
    ../../vsf/source/shell/sys/linux/lib/3rd-party/getopt/: getopt_long.c
  group vsf/shell/sys/linux/lib/3rd-party/glob
    ../../vsf/source/shell/sys/linux/lib/3rd-party/glob/: glob.c
  group vsf/shell/sys/linux/lib/3rd-party/regex
    ../../vsf/source/shell/sys/linux/lib/3rd-party/regex/: regcomp.c regerror.c regexec.c regfree.c
  group vsf/shell/sys/linux/lib/glibc
    ../../vsf/source/shell/sys/linux/lib/glibc/: vsf_linux_glibc.c vsf_linux_glibc_ctype.c vsf_linux_glibc_pthread.c vsf_linux_glibc_sem.c vsf_linux_glibc_stdio.c vsf_linux_glibc_stdlib.c vsf_linux_glibc_string.c vsf_linux_glibc_time.c
  group vsf/shell/sys/linux/lib/libgen
    ../../vsf/source/shell/sys/linux/lib/libgen/: vsf_linux_libgen.c
  group vsf/shell/sys/linux/lib/libusb
    ../../vsf/source/shell/sys/linux/lib/libusb/: vsf_linux_libusb.c
  group vsf/shell/sys/linux/port/busybox
    ../../vsf/source/shell/sys/linux/port/busybox/: busybox.c busybox.h config.h
  group vsf/shell/sys/linux/port/busybox/shell
    ../../vsf/source/shell/sys/linux/port/busybox/shell/: vsh.c
  group vsf/utilities
    ../../vsf/source/utilities/: communicate.h ooc_class.h vsf_utilities.h
  group vsf/utilities/3rd-party/PLOOC/raw
    ../../vsf/source/utilities/3rd-party/PLOOC/raw/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_simple_c90.h plooc_class_strict.h
  group vsf/utilities/compiler
    ../../vsf/source/utilities/compiler/arm/: arm_compiler.c arm_compiler.h retarget_io.c type.h
    ../../vsf/source/utilities/compiler/: compiler.h vsf_compiler.c
  group vsf/utilities/compiler/__common
    ../../vsf/source/utilities/compiler/__common/: __compiler.h __retarget_io.c __type.h
  group vsf/utilities/compiler/__common/__retarget_io
    ../../vsf/source/utilities/compiler/__common/__retarget_io/: __retarget_io_gcc_llvm.c __retarget_io_iar.c
  group vsf/utilities/language_extension
    ../../vsf/source/utilities/language_extension/: code_region.c code_region.h delegate.c language_extension.h simple_sprintf.c simple_sscanf.c
  group vsf/utilities/preprocessor
    ../../vsf/source/utilities/preprocessor/: mf_u8_dec2str.h vsf_connect_macro.h vsf_foreach_macro.h vsf_macro_calc.h vsf_preprocessor.h vsf_repeat_macro.h
  group vsf/utilities/template
    ../../vsf/source/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h vsf_queue.c vsf_queue.h
